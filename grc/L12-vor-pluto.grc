options:
  parameters:
    author: ECE 448
    description: 'L12: an AM receiver for a VOR on a PlutoSDR, 108 to 118 MHz, to hear its Morse identifier, a 1020 Hz tone keyed every few seconds. Type the station frequency into VOR (MHz). Receive only: there is no transmit block. Needs a PlutoSDR.'
    generate_options: qt_gui
    id: L12_vor_pluto
    output_language: python
    title: L12 - VOR Identifier on a PlutoSDR
  states: {}

blocks:
- name: chan_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    samp_rate: radio_rate
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: samp_rate * 32
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: vor_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: VOR (MHz)
    type: real
    value: '112.0'
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: 1e5
    reference: '1.0'
    type: complex
  states: {}
- name: am
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: samp_rate
  states: {}
- name: band
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    fc: vor_mhz * 1e6 - offset
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,2
    legend: 'False'
    name: '"Band around the VOR"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: channel
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: vor_mhz * 1e6
    fftsize: '4096'
    gui_hint: 2,0,1,2
    int_max: '-20'
    int_min: '-100'
    name: '"The VOR channel: the identifier is the dashes 1020 Hz either side"'
    type: complex
  states: {}
- name: pluto_source
  id: iio_pluto_source
  parameters:
    bandwidth: int(radio_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(vor_mhz * 1e6 - offset)
    gain1: '''slow_attack'''
    len_tag_key: '""'
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(radio_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: speaker
  id: audio_sink
  parameters:
    device_name: ''''''
    samp_rate: '48000'
  states: {}
- name: tune
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '32'
    samp_rate: radio_rate
    taps: chan_taps
    type: ccc
  states: {}
- name: vol
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}

connections:
- [agc, '0', am, '0']
- [agc, '0', channel, '0']
- [am, '0', vol, '0']
- [pluto_source, '0', band, '0']
- [pluto_source, '0', tune, '0']
- [tune, '0', agc, '0']
- [vol, '0', speaker, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
