options:
  parameters:
    author: ECE 448
    description: 'L7: an AM receiver for the aircraft band. Plays L07-am-test.sigmf-data; disable the File Source and enable the PlutoSDR Source to receive a live AM station such as an airport ATIS.'
    generate_options: qt_gui
    id: L07_am_rx
    output_language: python
    title: L7 - AM Receiver
  states: {}

blocks:
- name: chan_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: '"SDR center (MHz)"'
    type: real
    value: '126.0'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: 48e3
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: station_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: '"Station (MHz)"'
    type: real
    value: '126.2'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '0.3'
    type: float
  states: {}
- name: audio_scope
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,2,1,2
    legend: 'False'
    name: '"Audio after the AGC"'
    size: '480'
    srate: 48e3
    type: float
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: channel_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (station_mhz - fc_mhz) * 1e6
    decim: '50'
    samp_rate: samp_rate
    taps: chan_taps
    type: ccc
  states: {}
- name: channel_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 48e3
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Channel after the filter"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: dc_block
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: envelope
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: envelope_lpf
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lpf_taps
    type: fff
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: L07-am-test.sigmf-data
    repeat: 'True'
    type: complex
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: fc_mhz * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,4
    legend: 'False'
    name: '"Received band"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: volume
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}

connections:
- [agc, '0', audio_scope, '0']
- [agc, '0', volume, '0']
- [channel_filter, '0', channel_spectrum, '0']
- [channel_filter, '0', envelope, '0']
- [dc_block, '0', agc, '0']
- [envelope, '0', envelope_lpf, '0']
- [envelope_lpf, '0', dc_block, '0']
- [file_source, '0', channel_filter, '0']
- [file_source, '0', rf_spectrum, '0']
- [pluto, '0', channel_filter, '0']
- [pluto, '0', rf_spectrum, '0']
- [volume, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
