options:
  parameters:
    author: ECE 448
    description: 'L7: the WBFM receiver of L07-wbfm-rx.grc plus an RDS decoder on the 57 kHz subcarrier. Plays L07-fm-test.sigmf-data; disable the File Source and enable the PlutoSDR Source to receive live. Needs gr-rds (gnuradio-rds in radioconda).'
    generate_options: qt_gui
    id: L07_rds_rx
    output_language: python
    title: L7 - Broadcast FM with RDS
  states: {}

blocks:
- name: biphase_taps
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n + 8] for n in range(len(rrc_taps) - 8)]'
  states: {}
- name: chan_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 105e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 30e3
    win: window.WIN_HAMMING
  states: {}
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: '"SDR center (MHz)"'
    type: real
    value: '100.0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: 19e3
    sym_rate: 19e3 / 8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: station_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: '"Station (MHz)"'
    type: real
    value: '100.3'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: audio_filter
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0, samp_rate / 10, 15e3, 3e3)
    type: fff
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: carrier_recovery
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2 * math.pi / 100
  states: {}
- name: channel_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (station_mhz - fc_mhz) * 1e6
    decim: '10'
    samp_rate: samp_rate
    taps: chan_taps
    type: ccc
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    name: '"RDS symbols"'
    size: '512'
    type: complex
  states: {}
- name: deemphasis
  id: analog_fm_deemph
  parameters:
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: diff_decoder
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: L07-fm-test.sigmf-data
    repeat: 'True'
    type: complex
  states: {}
- name: fm_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / 10 / (2 * math.pi * 75e3)
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: matched_filter
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: biphase_taps
    type: ccc
  states: {}
- name: mpx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / 10
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 2,0,1,4
    legend: 'False'
    name: '"Demodulated multiplex"'
    type: float
    ymax: '0'
    ymin: '-100'
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: rds_agc
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: rds_decoder
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_null
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: rds_panel
  id: rds_panel
  parameters:
    freq: station_mhz * 1e6
    gui_hint: 3,1,1,3
  states: {}
- name: rds_parser
  id: rds_parser
  parameters:
    pty_locale: '1'
  states: {}
- name: rds_shift
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '10'
    samp_rate: samp_rate / 10
    taps: firdes.low_pass(1.0, samp_rate / 10, 7.5e3, 5e3)
    type: fcc
  states: {}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: fc_mhz * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,4
    legend: 'False'
    name: '"Received band"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: to_19k
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '19'
    type: ccc
  states: {}
- name: volume
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}

connections:
- [audio_filter, '0', deemphasis, '0']
- [carrier_recovery, '0', diff_decoder, '0']
- [carrier_recovery, '1', rds_null, '0']
- [carrier_recovery, '2', rds_null, '1']
- [carrier_recovery, '3', rds_null, '2']
- [carrier_recovery, '4', constellation, '0']
- [channel_filter, '0', fm_demod, '0']
- [deemphasis, '0', volume, '0']
- [diff_decoder, '0', rds_decoder, '0']
- [file_source, '0', channel_filter, '0']
- [file_source, '0', rf_spectrum, '0']
- [fm_demod, '0', audio_filter, '0']
- [fm_demod, '0', mpx_spectrum, '0']
- [fm_demod, '0', rds_shift, '0']
- [matched_filter, '0', rds_agc, '0']
- [pluto, '0', channel_filter, '0']
- [pluto, '0', rf_spectrum, '0']
- [rds_agc, '0', symbol_sync, '0']
- [rds_decoder, out, rds_parser, in]
- [rds_parser, out, rds_panel, in]
- [rds_shift, '0', to_19k, '0']
- [symbol_sync, '0', carrier_recovery, '0']
- [to_19k, '0', matched_filter, '0']
- [volume, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
