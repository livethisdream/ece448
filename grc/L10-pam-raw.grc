options:
  parameters:
    author: ECE 448
    description: 'L10 Lab: the PAM link with no access code or header. The receiver groups the bits into bytes from wherever it starts; move the bit offset until the text reads.'
    generate_options: qt_gui
    id: L10_pam_raw
    output_language: python
    title: L10 - Raw Bits, No Packets
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bit_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Bit offset
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: msg
  id: variable
  parameters:
    value: '''USAFA ECE 448: ASCII over PAM.'''
  states: {}
- name: rx_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: '':  '' + x'
    gui_hint: 1,0,1,1
    label: Received bytes
    type: string
    value: rx_text
  states: {}
- name: rx_start
  id: variable
  parameters:
    value: random.randint(0, 999)
  states: {}
- name: rx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/sps, alpha, 11*sps)
  states: {}
- name: rx_text
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: text
    poll_rate: '4'
    value: ''''''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, samp_rate, samp_rate/sps, alpha, 11*sps)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Channel
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Shifts the bits by the offset
    delay: bit_offset
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: The receiver starts listening at a random bit
    num_items: rx_start
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/sps
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(msg.encode()) + [10]
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Raw Text: shows the last 40 bytes from Repack Bits as text, with no packets.
      A byte that does not print as an ASCII character shows as a dot, and a newline
      as a bar. A Function Probe reads text() for the QT GUI Label."""

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, width=40):
              gr.sync_block.__init__(self, name='Raw Text', in_sig=[np.uint8], out_sig=None)
              self.width = width
              self.buf = ''

          def work(self, input_items, output_items):
              for b in input_items[0]:
                  self.buf += '|' if b == 10 else (chr(b) if 32 <= b < 127 else '.')
              self.buf = self.buf[-self.width:]
              return len(input_items[0])

          def text(self):
              return self.buf
    width: '40'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Matched filter
    decim: '1'
    taps: rx_taps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Transmitter
    interp: sps
    taps: tx_taps
    type: fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_skiphead_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
