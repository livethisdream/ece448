options:
  parameters:
    author: ECE 448
    description: 'L14: writes L14-hd-test.sigmf-data and .sigmf-meta, 4 s of a simulated hybrid HD Radio station: an FM host, two OFDM sidebands at levels set by upper_dbc and lower_dbc, an analog-only neighbor, and noise, as unsigned 8-bit IQ (SigMF datatype cu8) at 1,488,375 samples per second, the default input format of nrsc5. GNU Radio''s SigMF Sink takes no cu8, so a File Sink writes the samples and the write_meta snippet writes the .sigmf-meta. Simulated: the sidebands carry random QPSK, not NRSC-5 data. Nothing transmits.'
    generate_options: no_gui
    id: L14_hd_test_tx
    output_language: python
    run_options: run
    title: L14 - HD Radio Test File
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: samp_rate / 25
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '224'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 100.3e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: inner
  id: variable
  parameters:
    value: '356'
  states: {}
- name: lower_carriers
  id: variable
  parameters:
    value: list(range(-546, -inner + 1))
  states: {}
- name: lower_dbc
  id: variable
  parameters:
    value: '-23'
  states: {}
- name: lower_gain
  id: variable
  parameters:
    value: (10**(lower_dbc/10) / len(lower_carriers))**0.5
  states: {}
- name: neighbor_khz
  id: variable
  parameters:
    value: '-400'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: rec_name
  id: variable
  parameters:
    value: '''L14-hd-test'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1488375'
  states: {}
- name: seconds
  id: variable
  parameters:
    value: '4'
  states: {}
- name: upper_carriers
  id: variable
  parameters:
    value: list(range(inner, 547))
  states: {}
- name: upper_dbc
  id: variable
  parameters:
    value: '-23'
  states: {}
- name: upper_gain
  id: variable
  parameters:
    value: (10**(upper_dbc/10) / len(upper_carriers))**0.5
  states: {}
- name: combine
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: file_sink
  id: blocks_file_sink
  parameters:
    file: rec_name + '.sigmf-data'
    type: byte
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: int(seconds * samp_rate)
    type: complex
  states: {}
- name: host_audio
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '16'
    type: float
  states: {}
- name: host_audio_lpf
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '0.33'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: host_fm
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * deviation / samp_rate
  states: {}
- name: host_mpx
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: host_upsample
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '25'
    type: fff
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: interleave
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: lower_alloc
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    occupied_carriers: (lower_carriers,)
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ()
  states: {}
- name: lower_bits
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '15'
    type: byte
  states: {}
- name: lower_cp
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    rolloff: '112'
    tagname: '""'
  states: {}
- name: lower_frame
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(lower_carriers)
    type: complex
  states: {}
- name: lower_ifft
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: lower_level
  id: blocks_multiply_const_vxx
  parameters:
    const: lower_gain
    type: complex
  states: {}
- name: lower_qpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j)/2**0.5, (-1+1j)/2**0.5, (-1-1j)/2**0.5, (1-1j)/2**0.5]'
  states: {}
- name: neighbor_audio
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '17'
    type: float
  states: {}
- name: neighbor_audio_lpf
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '0.33'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: neighbor_fm
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * deviation / samp_rate
  states: {}
- name: neighbor_mix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: neighbor_shift
  id: analog_sig_source_x
  parameters:
    amp: '0.316'
    freq: neighbor_khz * 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: neighbor_upsample
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '25'
    type: fff
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '18'
    type: complex
  states: {}
- name: offset
  id: blocks_add_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: pilot
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    const: '70'
    type: float
  states: {}
- name: to_iq
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: to_uchar
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: upper_alloc
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    occupied_carriers: (upper_carriers,)
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ()
  states: {}
- name: upper_bits
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '14'
    type: byte
  states: {}
- name: upper_cp
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    rolloff: '112'
    tagname: '""'
  states: {}
- name: upper_frame
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(upper_carriers)
    type: complex
  states: {}
- name: upper_ifft
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: upper_level
  id: blocks_multiply_const_vxx
  parameters:
    const: upper_gain
    type: complex
  states: {}
- name: upper_qpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j)/2**0.5, (-1+1j)/2**0.5, (-1-1j)/2**0.5, (1-1j)/2**0.5]'
  states: {}
- name: write_meta
  id: snippet
  parameters:
    code: |-
      import json
      meta = {'global': {'core:datatype': 'cu8', 'core:sample_rate': float(self.samp_rate),
          'core:version': '1.0.0', 'core:hw': 'Simulated: L14-hd-test-tx.grc',
          'core:description': 'Simulated hybrid HD Radio station'},
          'captures': [{'core:sample_start': 0, 'core:frequency': float(self.fc)}],
          'annotations': []}
      with open(self.rec_name + '.sigmf-meta', 'w') as f:
          json.dump(meta, f, indent=2)
    section: main_after_init
  states: {}

connections:
- [combine, '0', head, '0']
- [head, '0', to_iq, '0']
- [host_audio, '0', host_audio_lpf, '0']
- [host_audio_lpf, '0', host_upsample, '0']
- [host_fm, '0', combine, '0']
- [host_mpx, '0', host_fm, '0']
- [host_upsample, '0', host_mpx, '0']
- [interleave, '0', scale, '0']
- [lower_alloc, '0', lower_ifft, '0']
- [lower_bits, '0', lower_qpsk, '0']
- [lower_cp, '0', lower_level, '0']
- [lower_frame, '0', lower_alloc, '0']
- [lower_ifft, '0', lower_cp, '0']
- [lower_level, '0', combine, '3']
- [lower_qpsk, '0', lower_frame, '0']
- [neighbor_audio, '0', neighbor_audio_lpf, '0']
- [neighbor_audio_lpf, '0', neighbor_upsample, '0']
- [neighbor_fm, '0', neighbor_mix, '0']
- [neighbor_mix, '0', combine, '1']
- [neighbor_shift, '0', neighbor_mix, '1']
- [neighbor_upsample, '0', neighbor_fm, '0']
- [noise, '0', combine, '4']
- [offset, '0', to_uchar, '0']
- [pilot, '0', host_mpx, '1']
- [scale, '0', offset, '0']
- [to_iq, '0', interleave, '0']
- [to_iq, '1', interleave, '1']
- [to_uchar, '0', file_sink, '0']
- [upper_alloc, '0', upper_ifft, '0']
- [upper_bits, '0', upper_qpsk, '0']
- [upper_cp, '0', upper_level, '0']
- [upper_frame, '0', upper_alloc, '0']
- [upper_ifft, '0', upper_cp, '0']
- [upper_level, '0', combine, '2']
- [upper_qpsk, '0', upper_frame, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
