options:
  parameters:
    author: ECE 448
    description: 'L17: open a SigMF recording, find the carrier on the spectrum and waterfall, shift it to 0 Hz, and watch its envelope. Set rec, samp_rate, and fc from the .sigmf-meta file. No hardware; transmits nothing.'
    generate_options: qt_gui
    id: L17_sigmf_view
    output_language: python
    title: L17 - SigMF Viewer
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 350e6
  states: {}
- name: rec
  id: variable
  parameters:
    value: '"L17-fan-remote.sigmf-data"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Carrier offset (Hz)
    min_len: '300'
    start: '-100000'
    step: '500'
    stop: '100000'
    value: '0'
  states: {}
- name: env
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: envelope
    legend: 'False'
    name: '"Envelope after the shift"'
    size: '8000'
    srate: samp_rate
    tr_delay: '0.002'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.4'
    ymin: '0'
  states: {}
- name: freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: src
  id: blocks_sigmf_source_minimal
  parameters:
    file: rec
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: thr
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: 1,1,1,1
    int_max: '-20'
    int_min: '-90'
    name: '"Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}
- name: xlate
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10000, 5000)
    type: ccc
  states: {}

connections:
- [mag, '0', env, '0']
- [src, '0', thr, '0']
- [thr, '0', freq, '0']
- [thr, '0', wf, '0']
- [thr, '0', xlate, '0']
- [xlate, '0', mag, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
