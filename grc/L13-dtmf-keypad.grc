options:
  parameters:
    author: ECE 448
    description: 'L13: one DTMF key. Choose a key, hold Press, and hear and see its two tones.'
    generate_options: qt_gui
    id: L13_dtmf_keypad
    output_language: python
    title: L13 - DTMF Keypad
  states: {}

blocks:
- name: col_f
  id: variable
  parameters:
    value: '[1209, 1336, 1477, 1633][key % 4]'
  states: {}
- name: key
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: Key
    labels: '[''1'', ''2'', ''3'', ''A'', ''4'', ''5'', ''6'', ''B'', ''7'', ''8'', ''9'', ''C'', ''*'', ''0'', ''#'', ''D'']'
    num_opts: '0'
    options: list(range(16))
    orient: Qt.QHBoxLayout
    type: int
    value: '5'
    widget: radio_buttons
  states: {}
- name: press
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,0,1,2
    label: Press
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: row_f
  id: variable
  parameters:
    value: '[697, 770, 852, 941][key // 4]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    device_name: ''''''
    samp_rate: '48000'
  states: {}
- name: col_src
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: Column tone
    freq: col_f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: fsink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    gui_hint: 2,1,1,1
    label1: Key
    name: '"Spectrum"'
    type: float
    ymax: '0'
    ymin: '-100'
  states: {}
- name: gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 0 until Press is held
    const: press
    type: float
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: row_src
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: Row tone
    freq: row_f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: tsink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    label1: Key
    name: '"Waveform"'
    size: '160'
    srate: samp_rate
    type: float
    ymax: '0.7'
    ymin: '-0.7'
  states: {}

connections:
- [add, '0', gate, '0']
- [col_src, '0', add, '1']
- [gate, '0', fsink, '0']
- [gate, '0', resamp, '0']
- [gate, '0', tsink, '0']
- [resamp, '0', audio_out, '0']
- [row_src, '0', add, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
