options:
  parameters:
    author: ECE 448
    description: 'L17: receive only. An RTL-SDR Source at 1.024 MS/s with spectrum, waterfall, and envelope displays, recording to capture.sigmf-data and .sigmf-meta. Set the variable fc before you run it: the SigMF Sink writes core:frequency when the flowgraph starts, so fc is not a runtime control. The AGC feeds only the envelope display; the recording keeps the raw samples. Optional: needs an RTL-SDR; nothing in L17 or its lab needs one, and L17-capture.grc is the PlutoSDR version every cadet uses.'
    generate_options: qt_gui
    id: L17_capture_rtl
    output_language: python
    title: L17 - Capture to SigMF (RTL-SDR)
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: agc
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '0.0001'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000000.0'
    reference: '1.0'
    type: complex
  states: {}
- name: env
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Envelope (after the AGC, display only)"'
    size: '51200'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: rec
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: fc
    filename: capture
    hw_info: RTL-SDR
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: rtl
  id: soapy_rtlsdr_source
  parameters:
    center_freq: fc
    dev_args: ''''''
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: 1,1,1,1
    int_max: '-30'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [agc, '0', mag, '0']
- [mag, '0', env, '0']
- [rtl, '0', agc, '0']
- [rtl, '0', freq, '0']
- [rtl, '0', rec, '0']
- [rtl, '0', wf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
