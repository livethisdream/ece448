options:
  parameters:
    author: ECE 448
    description: 'L14: the spectrum, waterfall, and sideband power of an FM station with HD Radio, from L14-hd-test.sigmf-data, any unsigned 8-bit (cu8) recording at 1,488,375 samples per second, or a PlutoSDR live. To go live, disable the File Source and the six blocks after it and enable the PlutoSDR Source. The disabled Rational Resampler and SigMF Sink record the Pluto at half rate, 744,187.5 samples per second, as hd.sigmf-data for nrsc5. Receive only.'
    generate_options: qt_gui
    id: L14_hd_find
    output_language: python
    title: L14 - Finding the HD Radio Sidebands
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    value: int(0.2 * samp_rate / decim)
  states: {}
- name: decim
  id: variable
  parameters:
    value: '6'
  states: {}
- name: df
  id: variable
  parameters:
    value: 1488375 / 4096
  states: {}
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Center (MHz)
    type: real
    value: '100.3'
  states: {}
- name: host_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: inner
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Inner subcarrier
    rangeType: int
    start: '280'
    step: '19'
    stop: '356'
    value: '356'
  states: {}
- name: iq_file
  id: variable
  parameters:
    value: '''L14-hd-test.sigmf-data'''
  states: {}
- name: outer
  id: variable
  parameters:
    value: '546'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1488375'
  states: {}
- name: sb_center
  id: variable
  parameters:
    value: (inner + outer) / 2 * df
  states: {}
- name: sb_half
  id: variable
  parameters:
    value: ((outer - inner) / 2 + 0.5) * df
  states: {}
- name: sb_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: sb_half
    gain: '1'
    samp_rate: samp_rate
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: difference
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: iq_file
    repeat: 'True'
    type: byte
  states: {}
- name: half_rate
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: host_average
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1 / avg_len
    type: float
  states: {}
- name: host_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: host_filter
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: host_taps
  states: {}
- name: host_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: host_slow
  id: blocks_keep_one_in_n
  parameters:
    n: avg_len // 10
    type: float
  states: {}
- name: lower_average
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1 / avg_len
    type: float
  states: {}
- name: lower_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: lower_dbc
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: lower_filter
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-sb_center'
    decim: decim
    samp_rate: samp_rate
    taps: sb_taps
  states: {}
- name: lower_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: lower_slow
  id: blocks_keep_one_in_n
  parameters:
    n: avg_len // 10
    type: float
  states: {}
- name: nrsc5_file
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: fc_mhz * 1e6
    filename: hd
    hw_info: PlutoSDR
    sample_rate: samp_rate / 2
    type: complex float (fc32_le)
  states: {state: disabled}
- name: number
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,3
    label1: '"Upper sideband"'
    label2: '"Lower sideband"'
    label3: '"Upper minus lower"'
    max: '0'
    min: '-40'
    name: '"Sideband power"'
    nconnections: '3'
    type: float
    unit1: '"dBc"'
    unit2: '"dBc"'
    unit3: '"dB"'
    update_time: '0.2'
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: recenter
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: rescale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 / 128
    type: float
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: fc_mhz * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,1,3
    label1: '""'
    legend: 'False'
    name: '"Received band"'
    type: complex
    update_time: '0.2'
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: split_iq
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: 2 * samp_rate
    type: byte
  states: {}
- name: to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: to_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: upper_average
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1 / avg_len
    type: float
  states: {}
- name: upper_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: upper_dbc
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: upper_filter
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: sb_center
    decim: decim
    samp_rate: samp_rate
    taps: sb_taps
  states: {}
- name: upper_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: upper_slow
  id: blocks_keep_one_in_n
  parameters:
    n: avg_len // 10
    type: float
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc_mhz * 1e6
    fftsize: '4096'
    gui_hint: 3,0,1,3
    int_max: '-30'
    int_min: '-110'
    label1: '""'
    name: '"Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [difference, '0', number, '2']
- [file_source, '0', throttle, '0']
- [half_rate, '0', nrsc5_file, '0']
- [host_average, '0', host_slow, '0']
- [host_db, '0', lower_dbc, '1']
- [host_db, '0', upper_dbc, '1']
- [host_filter, '0', host_power, '0']
- [host_power, '0', host_average, '0']
- [host_slow, '0', host_db, '0']
- [lower_average, '0', lower_slow, '0']
- [lower_db, '0', difference, '1']
- [lower_db, '0', lower_dbc, '0']
- [lower_dbc, '0', number, '1']
- [lower_filter, '0', lower_power, '0']
- [lower_power, '0', lower_average, '0']
- [lower_slow, '0', lower_db, '0']
- [pluto, '0', half_rate, '0']
- [pluto, '0', host_filter, '0']
- [pluto, '0', lower_filter, '0']
- [pluto, '0', spectrum, '0']
- [pluto, '0', upper_filter, '0']
- [pluto, '0', waterfall, '0']
- [recenter, '0', rescale, '0']
- [rescale, '0', split_iq, '0']
- [split_iq, '0', to_complex, '0']
- [split_iq, '1', to_complex, '1']
- [throttle, '0', to_float, '0']
- [to_complex, '0', host_filter, '0']
- [to_complex, '0', lower_filter, '0']
- [to_complex, '0', spectrum, '0']
- [to_complex, '0', upper_filter, '0']
- [to_complex, '0', waterfall, '0']
- [to_float, '0', recenter, '0']
- [upper_average, '0', upper_slow, '0']
- [upper_db, '0', difference, '0']
- [upper_db, '0', upper_dbc, '0']
- [upper_dbc, '0', number, '0']
- [upper_filter, '0', upper_power, '0']
- [upper_power, '0', upper_average, '0']
- [upper_slow, '0', upper_db, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
