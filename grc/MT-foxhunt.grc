options:
  parameters:
    author: ECE 448
    description: 'Midterm fox hunt: receive only. A PlutoSDR Source at 1 MS/s tuned 250 kHz below 915 MHz, so the Pluto''s DC spike stays off the fox. Spectrum and waterfall show the whole 1 MHz around 915 MHz; a Frequency Xlating FIR Filter picks out a channel centered on 915 MHz, Channel width wide, and two readouts show its power in dBFS: the 100 ms average and the strongest 2 ms in the last quarter second, which catches short bursts. The ADC level readout shows the largest I or Q sample; at 1.0 the ADC clips, so lower the RX gain. Needs a PlutoSDR in extended-frequency mode (70 MHz to 6 GHz). It transmits nothing.'
    generate_options: qt_gui
    id: MT_foxhunt
    output_language: python
    title: Midterm Fox Hunt
  states: {}

blocks:
- name: ch_rate
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: chan_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Channel width (Hz)
    start: 50e3
    step: 5e3
    stop: 250e3
    value: 200e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: if_off
  id: variable
  parameters:
    comment: LO sits this far below fc
    value: 250e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: abs_i
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: abs_q
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: adc_readout
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,1,1,1
    label1: '"Largest I or Q sample"'
    min: '0'
    name: '"ADC level (1.0 = clipping)"'
    type: float
    unit1: '""'
    update_time: '0.25'
  states: {}
- name: avg100
  id: blocks_moving_average_xx
  parameters:
    length: int(ch_rate*0.1)
    max_iter: '4000'
    scale: 1/int(ch_rate*0.1)
    type: float
  states: {}
- name: avg2
  id: blocks_moving_average_xx
  parameters:
    length: int(ch_rate*0.002)
    max_iter: '4000'
    scale: 1/int(ch_rate*0.002)
    type: float
  states: {}
- name: avg_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: avg_out
  id: blocks_keep_one_in_n
  parameters:
    n: int(ch_rate/4)
    type: float
  states: {}
- name: channel
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_off
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, chan_bw/2, chan_bw/8)
    type: ccf
  states: {}
- name: clip_max1
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1000'
    vlen_out: '1'
  states: {}
- name: clip_max2
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '250'
    vlen_out: '1'
  states: {}
- name: clip_vec1
  id: blocks_stream_to_vector
  parameters:
    num_items: '1000'
    type: float
  states: {}
- name: clip_vec2
  id: blocks_stream_to_vector
  parameters:
    num_items: '250'
    type: float
  states: {}
- name: iq
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: iq_max
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: peak_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: peak_dec
  id: blocks_keep_one_in_n
  parameters:
    n: int(ch_rate*0.0005)
    type: float
  states: {}
- name: peak_max
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '500'
    vlen_out: '1'
  states: {}
- name: peak_vec
  id: blocks_stream_to_vector
  parameters:
    num_items: '500'
    type: float
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc - if_off)
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: power_readout
  id: qtgui_number_sink
  parameters:
    color2: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    label1: '"Average, 100 ms"'
    label2: '"Peak, strongest 2 ms"'
    max: '0'
    min: '-100'
    name: '"Channel power"'
    nconnections: '2'
    type: float
    unit1: '"dBFS"'
    unit2: '"dBFS"'
    update_time: '0.25'
  states: {}
- name: pwr
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc - if_off
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,2
    name: '"Spectrum around 915 MHz"'
    type: complex
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc - if_off
    fftsize: '512'
    gui_hint: 2,0,1,2
    int_max: '-40'
    int_min: '-110'
    name: '"Waterfall: look for bursts and chirps"'
    type: complex
    update_time: '0.01'
  states: {}

connections:
- [abs_i, '0', iq_max, '0']
- [abs_q, '0', iq_max, '1']
- [avg100, '0', avg_out, '0']
- [avg2, '0', peak_dec, '0']
- [avg_db, '0', power_readout, '0']
- [avg_out, '0', avg_db, '0']
- [channel, '0', pwr, '0']
- [clip_max1, '0', clip_vec2, '0']
- [clip_max2, '0', adc_readout, '0']
- [clip_vec1, '0', clip_max1, '0']
- [clip_vec2, '0', clip_max2, '0']
- [iq, '0', abs_i, '0']
- [iq, '1', abs_q, '0']
- [iq_max, '0', clip_vec1, '0']
- [peak_db, '0', power_readout, '1']
- [peak_dec, '0', peak_vec, '0']
- [peak_max, '0', peak_db, '0']
- [peak_vec, '0', peak_max, '0']
- [pluto_rx, '0', channel, '0']
- [pluto_rx, '0', iq, '0']
- [pluto_rx, '0', spectrum, '0']
- [pluto_rx, '0', waterfall, '0']
- [pwr, '0', avg100, '0']
- [pwr, '0', avg2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
