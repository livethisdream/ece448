options:
  parameters:
    author: ECE 448
    description: 'L14: the steps from HD Radio sidebands to QPSK points, on any SigMF recording of datatype cu8 at 1,488,375 samples per second, by default L14-kut.sigmf-data, nrsc5''s sample capture of KUT 90.5, or on the PlutoSDR live. A band-pass filter keeps the two sidebands. The cyclic prefix, stacked over 16 symbols, marks where each OFDM symbol starts. An FFT turns each symbol into subcarriers, the reference subcarriers stand out as steady differential BPSK, and they equalize the data subcarriers into QPSK. The Added noise slider shows what a weaker signal does to each plot. To go live, disable the File Source and the six blocks after it and enable the PlutoSDR Source. Receive only.'
    generate_options: qt_gui
    id: L14_hd_demod
    output_language: python
    title: L14 - Demodulating the HD Radio Sidebands
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '224'
  states: {}
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2, 0, 1, 1
    label: Center (MHz), PlutoSDR
    type: real
    value: '100.3'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: iq_file
  id: variable
  parameters:
    value: '''L14-kut.sigmf-data'''
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 2, 1, 1
    label: Added noise
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1488375'
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: by_symbol
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len + cp_len
    type: complex
  states: {}
- name: data_plot
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1, 2, 1, 1
    legend: 'False'
    name: '"Data subcarriers (QPSK)"'
    size: '2048'
    type: complex
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: iq_file
    repeat: 'True'
    type: byte
  states: {}
- name: fine_readout
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3, 0, 1, 1
    label1: '"Hz"'
    max: '200'
    min: '-200'
    name: '"Tuning error within a subcarrier"'
    type: float
    unit1: '""'
  states: {}
- name: later
  id: blocks_delay
  parameters:
    delay: fft_len
    type: complex
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_len + cp_len
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: prefix_match
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: prefix_plot
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 0, 1, 1, 1
    legend: 'False'
    name: '"Cyclic prefix match, 16 symbols stacked"'
    vlen: fft_len + cp_len
    x_axis_label: '"Sample within one symbol"'
    x_start: '0'
    x_step: '1'
    y_axis_label: '"Match"'
    ymax: '1e-4'
    ymin: '0'
  states: {}
- name: prefix_window
  id: blocks_moving_average_xx
  parameters:
    length: cp_len
    max_iter: '4000'
    scale: 1 / cp_len
    type: complex
  states: {}
- name: raw_plot
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1, 1, 1, 1
    legend: 'False'
    name: '"Data subcarriers before equalization"'
    size: '2048'
    type: complex
  states: {}
- name: recenter
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: ref_plot
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1, 0, 1, 1
    legend: 'False'
    name: '"Reference subcarriers (BPSK)"'
    size: '1024'
    type: complex
  states: {}
- name: rescale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 / 128
    type: float
  states: {}
- name: score_plot
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0, 2, 1, 1
    legend: 'False'
    name: '"Reference subcarriers: steady differential BPSK"'
    vlen: '1201'
    x_axis_label: '"Subcarrier"'
    x_start: '-600'
    x_step: '1'
    y_axis_label: '"Score"'
    ymax: '1'
    ymin: '-0.2'
  states: {}
- name: sidebands
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1, samp_rate, 125e3, 202e3, 6e3)
    type: ccf
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0, 0, 1, 1
    label1: Recording
    label2: Sidebands only
    name: '"Recording and sidebands only"'
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: split_iq
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: stack
  id: blocks_moving_average_xx
  parameters:
    length: '16'
    max_iter: '4000'
    scale: 1 / 16
    type: complex
    vlen: fft_len + cp_len
  states: {}
- name: subcarriers
  id: epy_block
  parameters:
    _source_code: |
      """
      NRSC-5 Subcarriers: takes one FFT per symbol and pulls out the two kinds of
      subcarrier in the primary sidebands.

      Reference subcarriers sit every 19th subcarrier, 356 to 546 on each side.
      They carry differential BPSK, so multiplying each one by its value one symbol
      earlier gives two points, +1 and -1, whatever the channel did. A subcarrier
      that keeps doing that is a reference; the score output plots how strongly
      each of the fft_len subcarriers does, and the block finds the references (and any whole-subcarrier
      frequency offset) from where the score peaks.

      Between each pair of references are 18 data subcarriers, QPSK. The two
      references measure what the channel did to their neighborhood, and dividing
      each data subcarrier by that estimate leaves four points.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):

          def __init__(self, fft_len=4096, cp_len=224, search=40, span=600):
              self.N, self.search, self.span = int(fft_len), int(search), int(span)
              self.S = self.N + int(cp_len)
              gr.basic_block.__init__(self, name='NRSC-5 Subcarriers',
                                      in_sig=[(np.complex64, self.N)],
                                      out_sig=[(np.float32, 2 * self.span + 1),
                                               np.complex64, np.complex64,
                                               np.complex64, np.float32])
              upper = 356 + 19 * np.arange(11)
              self.refs = np.concatenate([-upper[::-1], upper])
              # Each data subcarrier, the references on either side, and how far
              # it sits between them.
              k, a, w = [], [], []
              for side in (-1, 1):
                  r = np.sort(side * upper)
                  for lo in r[:-1]:
                      for i in range(1, 19):
                          k.append(lo + i); a.append(lo); w.append(i / 19)
              self.k, self.a, self.w = np.array(k), np.array(a), np.array(w)
              self.score = np.zeros(self.N, np.float32)
              self.votes = np.zeros(2 * self.search + 1)
              self.prev = None
              self.offset = 0
              self.out = ([], [], [], [], [])

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def symbol(self, X):
              c = self.N // 2
              if self.prev is None:
                  self.prev = X
                  return
              d = X * np.conj(self.prev)
              # A symbol lasts fft_len + cp_len samples, so an offset of a whole
              # subcarrier still turns each subcarrier a little from one symbol to
              # the next. Try each offset with that turn taken out.
              shifts = np.arange(-self.search, self.search + 1)
              turn = np.exp(-2j * np.pi * shifts * self.S / self.N)
              dr = d[c + self.refs[None, :] + shifts[:, None]] * turn[:, None]
              votes = ((np.abs(dr.real) - np.abs(dr.imag)) / (np.abs(dr) + 1e-12)).sum(axis=1)
              self.votes = 0.9 * self.votes + 0.1 * votes
              self.offset = int(shifts[int(np.argmax(self.votes))])
              d = d * np.exp(-2j * np.pi * self.offset * self.S / self.N)
              s = (np.abs(d.real) - np.abs(d.imag)) / (np.abs(d) + 1e-12)
              self.score = 0.95 * self.score + 0.05 * s
              off = c + self.offset
              self.out[0].append(self.score[c - self.span:c + self.span + 1].copy())
              self.out[4].append(float(self.offset))
              r = off + self.refs
              ref = d[r] / (np.mean(np.abs(X[r]) * np.abs(self.prev[r])) + 1e-12)
              # What frequency error is left turns every reference the same way;
              # squaring removes the BPSK sign, so the average shows that turn.
              ref *= np.exp(-0.5j * np.angle(np.sum(ref ** 2)))
              self.out[1].extend(ref)
              raw = X[off + self.k]
              self.out[3].extend(raw / (np.mean(np.abs(raw)) + 1e-12))
              H2a = X[off + self.a] ** 2
              H2b = X[off + self.a + 19] ** 2
              H = np.sqrt((1 - self.w) * H2a + self.w * H2b)
              self.out[2].extend(X[off + self.k] / (H + 1e-12) * np.exp(1j * np.pi / 4))
              self.prev = X

          def general_work(self, input_items, output_items):
              # Decode only while the plots keep up, so nothing piles up here.
              used = 0
              for X in input_items[0]:
                  if len(self.out[2]) > 4096:
                      break
                  self.symbol(X)
                  used += 1
              self.consume(0, used)
              for port in range(5):
                  q = self.out[port]
                  n = min(len(q), len(output_items[port]))
                  for i in range(n):
                      output_items[port][i] = q[i]
                  del q[:n]
                  self.produce(port, n)
              return gr.WORK_CALLED_PRODUCE
    cp_len: cp_len
    fft_len: fft_len
    search: '40'
    span: '600'
  states: {}
- name: symbol_fft
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: symbol_sync
  id: epy_block
  parameters:
    _source_code: |
      """
      NRSC-5 Symbol Sync: finds where each OFDM symbol starts and removes the
      radio's fine frequency offset, both from the cyclic prefix, then hands the
      FFT one symbol at a time. Its second output is the tuning error it removed,
      in Hz, once per symbol.

      Every symbol is fft_len samples plus a cyclic prefix of cp_len: the symbol's
      last cp_len samples, copied to its front. Multiplying the signal by a copy of
      itself fft_len samples later lights up exactly where the copies line up, once
      per symbol, and the angle of that product is the tuning error, to within
      half a subcarrier. NRSC-5 fades each symbol in and out over cp_len samples,
      so instead of dropping the prefix the block fades it the same way again and
      adds the symbol's last cp_len samples onto its first ones, which rebuilds
      one full-strength symbol, the way nrsc5 does it.

      Feed it the sidebands only: the analog FM host is far stronger and has no
      cyclic prefix.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):

          def __init__(self, fft_len=4096, cp_len=224, samp_rate=1488375, symbols=16):
              self.N, self.CP = int(fft_len), int(cp_len)
              gr.basic_block.__init__(self, name='NRSC-5 Symbol Sync',
                                      in_sig=[np.complex64],
                                      out_sig=[(np.complex64, self.N), np.float32])
              self.fs, self.K = float(samp_rate), int(symbols)
              self.S = self.N + self.CP
              j = np.arange(self.S)
              self.shape = np.where(
                  j < self.CP, np.sin(np.pi / 2 * j / self.CP),
                  np.where(j < self.N, 1.0,
                           np.cos(np.pi / 2 * (j - self.N) / self.CP))).astype(np.float32)
              self.buf = np.zeros(0, np.complex64)
              self.ready = []         # (symbol, tuning error) waiting for room at the output
              self.phase = 0.0        # running phase of the frequency correction
              self.freq = 0.0         # latest frequency offset estimate, Hz
              self.start_index = 0    # latest symbol start, in samples

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def chunk(self):
              """Estimate timing and frequency over K symbols, then cut them out."""
              N, CP, S, K = self.N, self.CP, self.S, self.K
              seg = self.buf[:K * S + S]
              p = seg[:-N] * np.conj(seg[N:])
              c = np.concatenate([[0], np.cumsum(p)])
              m = c[CP:CP + K * S] - c[:K * S]           # sum over each cp_len window
              M = m.reshape(K, S).sum(axis=0)             # stack K symbols
              idx = int(np.argmax(np.abs(M)))
              self.start_index = idx
              self.freq = -np.angle(M[idx]) * self.fs / (2 * np.pi * N)
              w = -2 * np.pi * self.freq / self.fs
              n = np.arange(S)
              for i in range(K):
                  start = idx + i * S
                  v = seg[start:start + S] * np.exp(1j * (self.phase + w * (start + n))) * self.shape
                  body = v[:N].copy()
                  body[:CP] += v[N:]
                  self.ready.append((body.astype(np.complex64), self.freq))
              self.phase = (self.phase + w * K * S) % (2 * np.pi)
              self.buf = self.buf[K * S:]

          def general_work(self, input_items, output_items):
              need = self.K * self.S + self.S
              x = input_items[0]
              take = min(len(x), max(0, 2 * need - len(self.buf)))
              if take:
                  self.buf = np.concatenate([self.buf, x[:take]])
                  self.consume(0, take)
              while len(self.buf) >= need and len(self.ready) < 2 * self.K:
                  self.chunk()
              n = min(len(self.ready), len(output_items[0]), len(output_items[1]))
              for i in range(n):
                  output_items[0][i], output_items[1][i] = self.ready[i]
              del self.ready[:n]
              return n
    cp_len: cp_len
    fft_len: fft_len
    samp_rate: samp_rate
    symbols: '16'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: 2 * samp_rate
    type: byte
  states: {}
- name: to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: to_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: whole_readout
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3, 1, 1, 1
    label1: '"Subcarriers"'
    max: '40'
    min: '-40'
    name: '"Whole subcarriers off"'
    type: float
    unit1: '""'
  states: {}

connections:
- [add_noise, '0', sidebands, '0']
- [add_noise, '0', spectrum, '0']
- [by_symbol, '0', stack, '0']
- [file_source, '0', throttle, '0']
- [later, '0', prefix_match, '0']
- [mag, '0', prefix_plot, '0']
- [noise, '0', add_noise, '1']
- [pluto, '0', add_noise, '0']
- [prefix_match, '0', prefix_window, '0']
- [prefix_window, '0', by_symbol, '0']
- [recenter, '0', rescale, '0']
- [rescale, '0', split_iq, '0']
- [sidebands, '0', later, '0']
- [sidebands, '0', prefix_match, '1']
- [sidebands, '0', spectrum, '1']
- [sidebands, '0', symbol_sync, '0']
- [split_iq, '0', to_complex, '0']
- [split_iq, '1', to_complex, '1']
- [stack, '0', mag, '0']
- [subcarriers, '0', score_plot, '0']
- [subcarriers, '1', ref_plot, '0']
- [subcarriers, '2', data_plot, '0']
- [subcarriers, '3', raw_plot, '0']
- [subcarriers, '4', whole_readout, '0']
- [symbol_fft, '0', subcarriers, '0']
- [symbol_sync, '0', symbol_fft, '0']
- [symbol_sync, '1', fine_readout, '0']
- [throttle, '0', to_float, '0']
- [to_complex, '0', add_noise, '0']
- [to_float, '0', recenter, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
