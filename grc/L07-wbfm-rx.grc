options:
  parameters:
    author: ECE 448
    description: 'L7: a WBFM receiver. Plays L07-fm-test.sigmf-data; set the SigMF Source''s file to your fm_capture.sigmf-data and the center to the frequency in its .sigmf-meta, or disable the SigMF Source and enable the PlutoSDR Source to receive live.'
    generate_options: qt_gui
    id: L07_wbfm_rx
    output_language: python
    title: L7 - Broadcast FM Receiver
  states: {}

blocks:
- name: chan_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 105e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 30e3
    win: window.WIN_HAMMING
  states: {}
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: '"SDR center (MHz)"'
    type: real
    value: '100.0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: station_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: '"Station (MHz)"'
    type: real
    value: '100.3'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: audio_filter
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0, samp_rate / 10, 15e3, 3e3)
    type: fff
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 48e3
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 2,2,1,2
    legend: 'False'
    name: '"Audio after de-emphasis"'
    type: float
    ymax: '0'
    ymin: '-100'
  states: {}
- name: channel_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (station_mhz - fc_mhz) * 1e6
    decim: '10'
    samp_rate: samp_rate
    taps: chan_taps
    type: ccc
  states: {}
- name: deemphasis
  id: analog_fm_deemph
  parameters:
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: fm_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / 10 / (2 * math.pi * 75e3)
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: mpx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / 10
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Demodulated multiplex"'
    type: float
    ymax: '0'
    ymin: '-100'
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: fc_mhz * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,4
    legend: 'False'
    name: '"Received band"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: sigmf_source
  id: blocks_sigmf_source_minimal
  parameters:
    file: L07-fm-test.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: volume
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}

connections:
- [audio_filter, '0', deemphasis, '0']
- [channel_filter, '0', fm_demod, '0']
- [deemphasis, '0', audio_spectrum, '0']
- [deemphasis, '0', volume, '0']
- [fm_demod, '0', audio_filter, '0']
- [fm_demod, '0', mpx_spectrum, '0']
- [pluto, '0', channel_filter, '0']
- [pluto, '0', rf_spectrum, '0']
- [sigmf_source, '0', channel_filter, '0']
- [sigmf_source, '0', rf_spectrum, '0']
- [volume, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
