options:
  parameters:
    author: ECE 448
    description: 'L17: receive only. A PlutoSDR Source at 2 MS/s with spectrum, waterfall, and envelope displays and a Center frequency control you can change while it runs. It records nothing; L17-capture.grc records. Start at 433.72 MHz, 200 kHz below 433.92 MHz, so the DC spike stays off the Part 15 devices. The AGC feeds only the envelope display. Needs a PlutoSDR in extended-frequency mode (70 MHz to 6 GHz).'
    generate_options: qt_gui
    id: L17_explore_pluto
    output_language: python
    title: L17 - Explore the Band (PlutoSDR)
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center frequency (Hz)
    start: 70e6
    step: 10e3
    stop: 6e9
    value: 433.72e6
    widget: counter
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: agc
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '0.0001'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000000.0'
    reference: '1.0'
    type: complex
  states: {}
- name: env
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Envelope (after the AGC, display only)"'
    size: '50000'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: 1,1,1,1
    int_max: '-30'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [agc, '0', mag, '0']
- [mag, '0', env, '0']
- [pluto_rx, '0', agc, '0']
- [pluto_rx, '0', freq, '0']
- [pluto_rx, '0', wf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
