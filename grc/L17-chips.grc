options:
  parameters:
    author: ECE 448
    description: 'L17: no hardware; transmits nothing. Opens a SigMF recording, shifts the carrier to 0 Hz, and takes the envelope with Complex to Mag; raise the Envelope gain until the pulses reach about 1, as a weak capture needs. The time sink triggers at the threshold, so you can measure the shortest pulse. Add Const subtracts the threshold, Binary Slicer turns the envelope into 0s and 1s, and the Chip Reader keeps the middle sample of each chip from each burst''s first rising edge, as a Keep 1 in N would, and prints one line of chips per burst with the pause after it. Set rec, samp_rate, and fc from the .sigmf-meta file, then the carrier offset, the threshold, and chip_len in samples.'
    generate_options: qt_gui
    id: L17_chips
    output_language: python
    title: L17 - Read the Chips
  states: {}

blocks:
- name: chip_len
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Chip length (samples)
    min_len: '300'
    rangeType: int
    start: '1'
    step: '1'
    stop: '5000'
    value: '80'
  states: {}
- name: chips_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: '':  '' + x'
    gui_hint: 2,0,1,4
    label: Last burst
    type: string
    value: chips_text
  states: {}
- name: chips_text
  id: variable_function_probe
  parameters:
    block_id: reader
    function_name: last_line
    poll_rate: '4'
    value: '''(waiting for a burst)'''
  states: {}
- name: fc
  id: variable
  parameters:
    value: 350e6
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Envelope gain (dB)
    min_len: '300'
    start: '0'
    step: '1'
    stop: '80'
    value: '0'
  states: {}
- name: rec
  id: variable
  parameters:
    value: '"L17-fan-remote.sigmf-data"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Threshold
    min_len: '300'
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Carrier offset (Hz)
    min_len: '300'
    start: '-samp_rate/2'
    step: '500'
    stop: samp_rate/2
    value: '40000'
  states: {}
- name: env
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,4
    label1: envelope
    legend: 'False'
    name: '"Envelope after the shift"'
    size: int(0.04*samp_rate)
    srate: samp_rate
    tr_delay: '0.002'
    tr_level: thresh
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.4'
    ymin: '0'
  states: {}
- name: gain
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(gain_db/20)
    type: float
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: reader
  id: epy_block
  parameters:
    _source_code: |
      """Chip Reader: reads the sliced envelope, one 0 or 1 per sample, as one line of
      chips per burst. A burst's first rising edge starts the chip clock, and the
      reader keeps the sample in the middle of each chip, as a Keep 1 in N would.
      After 8 off chips the burst has ended: the line is printed, with the pause
      before the next burst in samples, and shown in the window."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, chip_len=80):
              gr.sync_block.__init__(self, name='Chip Reader', in_sig=[np.uint8], out_sig=None)
              self.chip_len = max(1, int(chip_len))
              self.runs = []       # (value, length) of the burst in progress
              self.active = False
              self.off = 0         # off samples since the last on sample
              self.line = None     # the last burst's chips, waiting for its pause
              self.shown = '(waiting for a burst)'

          def set_chip_len(self, chip_len):
              self.chip_len = max(1, int(chip_len))

          def last_line(self):
              return self.shown

          def work(self, input_items, output_items):
              x = (input_items[0] > 0).astype(np.uint8)
              edges = np.flatnonzero(np.diff(x)) + 1
              for seg in np.split(x, edges):
                  if len(seg) == 0:
                      continue
                  v, n = int(seg[0]), len(seg)
                  if v:
                      if not self.active:
                          if self.line is not None:
                              self.shown = '%d chips: %s  pause %d samples' % (len(self.line), self.line, self.off)
                              print(self.shown, flush=True)
                          self.active, self.runs = True, []
                      self.runs.append((1, n))
                      self.off = 0
                  else:
                      self.off += n
                      if self.active:
                          self.runs.append((0, n))
                          if self.off > 8 * self.chip_len:
                              env = np.repeat([r[0] for r in self.runs], [r[1] for r in self.runs])
                              chips = ''.join(str(c) for c in env[self.chip_len // 2::self.chip_len])
                              self.line = chips.rstrip('0')
                              self.active = False
              return len(input_items[0])
    chip_len: chip_len
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: src
  id: blocks_sigmf_source_minimal
  parameters:
    file: rec
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: sub
  id: blocks_add_const_vxx
  parameters:
    const: '-thresh'
    type: float
  states: {}
- name: thr
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: xlate
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10000, 5000)
    type: ccc
  states: {}

connections:
- [gain, '0', env, '0']
- [gain, '0', sub, '0']
- [mag, '0', gain, '0']
- [slicer, '0', reader, '0']
- [src, '0', thr, '0']
- [sub, '0', slicer, '0']
- [thr, '0', xlate, '0']
- [xlate, '0', mag, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
