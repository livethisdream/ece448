options:
  parameters:
    author: ECE 448
    description: 'L11: Morse ECE as a keyed carrier in noise, through the Energy Detector from the gr-ece448 module.'
    generate_options: qt_gui
    id: L11_keyed_carrier
    output_language: python
    title: L11 - Keyed Carrier
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: hyst
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Hysteresis (dB)
    start: '0'
    step: '0.5'
    stop: '10'
    value: '3'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise amplitude
    start: '0'
    step: '0.01'
    stop: '1.5'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Threshold (dB)
    start: '-30'
    step: '0.5'
    stop: '10'
    value: '-10'
  states: {}
- name: unit
  id: variable
  parameters:
    value: int(samp_rate * 1.2 / wpm)
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: threshold - hyst
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: unit
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[gr.tag_utils.python_to_tag((0, pmt.intern("ece"), pmt.PMT_T, pmt.intern("src")))]'
    type: float
    vector: '[1,0,0,0, 1,1,1,0,1,0,1,1,1,0,1,0,0,0, 1,0,0,0,0,0,0,0]'
  states: {}
- name: ece448_energy_detector_0
  id: ece448_energy_detector
  parameters:
    decim: decim
    hysteresis_db: hyst
    threshold_db: threshold
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: dark green
    color3: red
    entags: 'False'
    gui_hint: 1,0,1,3
    label1: Power
    label2: On level
    label3: Off level
    name: '"Power"'
    nconnections: '3'
    size: '1560'
    srate: samp_rate / decim
    style2: '2'
    style3: '2'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"ece"'
    type: float
    update_time: '0.1'
    width1: '2'
    ylabel: Power
    ymax: '10'
    ymin: '-40'
    yunit: dB
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color2: black
    entags: 'False'
    gui_hint: 2,0,1,3
    label1: Detected
    label2: Sent + 1.5
    name: '"Key"'
    nconnections: '2'
    size: '1560'
    srate: samp_rate / decim
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"ece"'
    type: float
    update_time: '0.1'
    width1: '2'
    width2: '2'
    ylabel: Key
    ymax: '2.75'
    ymin: '-0.25'
    yunit: ''
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0, '2']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle2_0, '0', ece448_energy_detector_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [ece448_energy_detector_0, '0', qtgui_time_sink_x_0, '0']
- [ece448_energy_detector_0, '1', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
