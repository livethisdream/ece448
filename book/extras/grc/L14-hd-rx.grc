options:
  parameters:
    author: ECE 448
    description: 'L14: plays an HD Radio station with gr-hdradio, from any SigMF recording of datatype cu8 at 1,488,375 samples per second, by default L14-kut.sigmf-data, nrsc5''s sample capture of KUT 90.5, or from the PlutoSDR live. The HD Radio Receiver decodes all four programs and the Program buttons pick which one plays. Station and song information print in the console, and album art and other station files go to the hd_files folder. The Added noise slider adds noise to the input, as a weaker station would. To go live, disable the File Source and the six blocks after it and enable the PlutoSDR Source. Needs gr-hdradio and nrsc5. Receive only.'
    generate_options: qt_gui
    id: L14_hd_rx
    output_language: python
    title: L14 - Decoding HD Radio
  states: {}

blocks:
- name: fc_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1, 0, 1, 1
    label: Center (MHz), PlutoSDR
    type: real
    value: '100.3'
  states: {}
- name: iq_file
  id: variable
  parameters:
    value: '''L14-kut.sigmf-data'''
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 2
    label: Added noise
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0'
  states: {}
- name: program
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 2
    label: Program
    label0: HD1
    label1: HD2
    label2: HD3
    label3: HD4
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1488375'
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: art
  id: hdradio_hd_file_sink
  parameters:
    directory: '''hd_files'''
    mime_types: '[]'
    overwrite: 'False'
    ports: '[]'
  states: {}
- name: console
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: iq_file
    repeat: 'True'
    type: byte
  states: {}
- name: hd
  id: hdradio_hd_receiver
  parameters:
    mode: '''fm'''
    offset: '0'
    paced: 'True'
    preroll: '0.5'
    programs: '[0, 1, 2, 3]'
    samp_rate: samp_rate
    stereo: 'True'
  states: {}
- name: left
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: program
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc_mhz * 1e6)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: recenter
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: rescale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 / 128
    type: float
  states: {}
- name: right
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: program
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: speaker
  id: audio_sink
  parameters:
    device_name: ''''''
    num_inputs: '2'
    samp_rate: '44100'
  states: {}
- name: split_iq
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: 2 * samp_rate
    type: byte
  states: {}
- name: to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: to_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}

connections:
- [add_noise, '0', hd, '0']
- [file_source, '0', throttle, '0']
- [hd, '0', left, '0']
- [hd, '1', right, '0']
- [hd, '2', left, '1']
- [hd, '3', right, '1']
- [hd, '4', left, '2']
- [hd, '5', right, '2']
- [hd, '6', left, '3']
- [hd, '7', right, '3']
- [hd, files, art, files]
- [hd, id3, console, print]
- [hd, station, console, print]
- [left, '0', speaker, '0']
- [noise, '0', add_noise, '1']
- [pluto, '0', add_noise, '0']
- [recenter, '0', rescale, '0']
- [rescale, '0', split_iq, '0']
- [right, '0', speaker, '1']
- [split_iq, '0', to_complex, '0']
- [split_iq, '1', to_complex, '1']
- [throttle, '0', to_float, '0']
- [to_complex, '0', add_noise, '0']
- [to_float, '0', recenter, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
