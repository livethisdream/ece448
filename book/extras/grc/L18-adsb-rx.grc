options:
  parameters:
    author: ECE 448
    description: 'L18: receive ADS-B from L18-adsb-sim.sigmf-data or a PlutoSDR at 2 MS/s, show the pulses, and decode each message with gr-adsb''s Framer, Demod, and Decoder. The Aircraft Table block only displays what the Decoder sends it. To go live, disable the SigMF Source and the Throttle and enable the PlutoSDR Source and its AGC: fc 1090e6 for real aircraft, or 915e6 for L18-adsb-tx-pluto.grc through the cable. Receive only.'
    generate_options: qt_gui
    id: L18_adsb_rx
    output_language: python
    title: L18 - ADS-B Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Added noise
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stats
  id: variable_function_probe
  parameters:
    block_id: table_0
    function_name: stats
    poll_rate: '2'
    value: '''0 bursts found, 0 decoded'''
  states: {}
- name: stats_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: Messages
    type: string
    value: stats
  states: {}
- name: table
  id: variable_function_probe
  parameters:
    block_id: table_0
    function_name: table
    poll_rate: '2'
    value: ''''''
  states: {}
- name: table_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,0,1,2
    label: Aircraft
    type: string
    value: table
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: Framer threshold (power)
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: adsb_framer_0
  id: adsb_framer
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: agc_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '1e-6'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e9
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: '''L18-adsb-sim.sigmf-data'''
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"20 ms of pulses"'
    size: '40000'
    srate: samp_rate
    type: float
    update_time: '0.2'
    ylabel: Power
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: '"One message: preamble and first bits"'
    size: '120'
    srate: samp_rate
    tr_delay: '5e-6'
    tr_level: '0.3'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.1'
    ylabel: Power
    ymin: '0'
  states: {}
- name: table_0
  id: epy_block
  parameters:
    _source_code: |
      """Aircraft Table: shows what gr-adsb's ADS-B Decoder has decoded.

      This block decodes nothing. gr-adsb's Demod sends every burst it finds to the
      "found" port, and its Decoder sends every message it decodes into an
      identity, a position, or a velocity, with everything it knows about that
      aircraft so far, to the "decoded" port. This
      block counts both and keeps one row per aircraft. Function Probes read
      stats() and table() for the QT GUI Labels; both start over when a slider in
      `settings` moves."""

      import math

      import numpy as np
      import pmt
      from gnuradio import gr


      def num(v, fmt):
          try:
              v = float(v)
          except (TypeError, ValueError):
              return ''
          return '' if math.isnan(v) else fmt.format(v)


      class blk(gr.basic_block):
          def __init__(self, settings=None):
              gr.basic_block.__init__(self, name='Aircraft Table', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('found'))
              self.message_port_register_in(pmt.intern('decoded'))
              self.set_msg_handler(pmt.intern('found'), self.on_found)
              self.set_msg_handler(pmt.intern('decoded'), self.on_decoded)
              self._settings = settings
              self.reset()

          def reset(self):
              self.n_found = 0
              self.n_decoded = 0
              self.planes = {}

          @property
          def settings(self):
              return self._settings

          @settings.setter
          def settings(self, value):
              if value != self._settings:
                  self.reset()
              self._settings = value

          def on_found(self, msg):
              self.n_found += 1

          def on_decoded(self, msg):
              self.n_decoded += 1
              d = pmt.to_python(pmt.car(msg))
              self.planes[d.get('icao', '?')] = d

          def stats(self):
              return f'{self.n_found} bursts found, {self.n_decoded} decoded'

          def table(self):
              rows = []
              for icao, d in sorted(self.planes.items()):
                  cs = (d.get('callsign') or '').strip()
                  alt = d.get('altitude')
                  alt = '' if alt == -1 else num(alt, '{:.0f} ft')   # -1: a format gr-adsb cannot read
                  spd = num(d.get('speed'), '{:.0f} kt')
                  # gr-adsb's heading is a math angle, 0 east and 90 north;
                  # a track is a compass angle, 0 north and 90 east
                  hdg = d.get('heading')
                  trk = num(None if hdg is None else (90 - float(hdg)) % 360, 'track {:.0f}')
                  lat, lon = num(d.get('latitude'), '{:.3f}'), num(d.get('longitude'), '{:.3f}')
                  pos = f'{lat}, {lon}' if lat and lon else ''
                  rows.append(f'{icao.upper()}  {cs}:  ' + ',  '.join(x for x in (alt, spd, trk, pos) if x))
              return '\n'.join(rows)
    settings: (noise, threshold)
  states: {}

connections:
- [adsb_decoder_0, decoded, table_0, decoded]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_demod_0, demodulated, table_0, found]
- [adsb_framer_0, '0', adsb_demod_0, '0']
- [agc_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [iio_pluto_source_0, '0', agc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
