options:
  parameters:
    author: ECE 448
    description: 'L18: receive ADS-B at 1090 MHz from L18-adsb-sim.sigmf-data or an RTL-SDR at 2 MS/s, show the pulses, and decode each message with the Mode S Decoder, an Embedded Python Block. To go live, disable the SigMF Source and the Throttle and enable the RTL-SDR Source. Receive only.'
    generate_options: qt_gui
    id: L18_adsb_rx
    output_language: python
    title: L18 - ADS-B Receiver
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Added noise
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF gain (dB)
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stats
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: stats
    poll_rate: '2'
    value: '''0 passed parity, 0 failed'''
  states: {}
- name: stats_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: Messages
    type: string
    value: stats
  states: {}
- name: table
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: table
    poll_rate: '2'
    value: ''''''
  states: {}
- name: table_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,0,1,2
    label: Aircraft
    type: string
    value: table
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: '''L18-adsb-sim.sigmf-data'''
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Mode S Decoder: finds ADS-B messages in the magnitude of a 2 MS/s stream.

      1. Find a preamble: pulses at chips 0, 2, 7, and 9, quiet between them.
      2. Read 112 bits: each bit is a pair of chips, and the larger one says
         which half held the pulse (pulse first is a 1).
      3. Check the 24 parity bits. A message that fails is counted and dropped.
      4. Print the message in hex and what it says, and update the aircraft table.

      Positions use the one-frame (local) decode, which is correct within about
      180 nautical miles of the reference position, here USAFA. Function Probes
      read stats() and table() for the QT GUI Labels."""

      import math

      import numpy as np
      from gnuradio import gr

      CHARS = '#ABCDEFGHIJKLMNOPQRSTUVWXYZ##### ###############0123456789######'
      HIGH = [0, 2, 7, 9]
      QUIET = [1, 3, 4, 5, 6, 8, 10, 11, 12, 13, 14, 15]
      N = 16 + 224


      def val(b):
          v = 0
          for x in b:
              v = (v << 1) | int(x)
          return v


      def remainder(b):
          """Zero for a message whose parity bits are right (generator 0x1FFF409)."""
          reg = 0
          for x in b:
              reg = (reg << 1) | int(x)
              if reg & 0x1000000:
                  reg ^= 0x1FFF409
          return reg


      def nl(lat):
          if abs(lat) >= 87:
              return 1
          a = 1 - math.cos(math.pi / 30)
          return int(2 * math.pi / math.acos(1 - a / math.cos(math.radians(lat)) ** 2))


      class blk(gr.sync_block):
          def __init__(self, samp_rate=2e6, ref_lat=38.99, ref_lon=-104.86, settings=None):
              gr.sync_block.__init__(self, name='Mode S Decoder', in_sig=[np.float32], out_sig=None)
              self.set_history(N)
              self.fs = samp_rate
              self.ref = (ref_lat, ref_lon)
              self.settings = settings

          @property
          def settings(self):
              return self._settings

          @settings.setter
          def settings(self, value):
              # GRC sets this when a slider it names moves: the counts and the
              # table start over.
              self._settings = value
              self.planes = {}
              self.good = 0
              self.bad = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x) - N + 1
              if n <= 0:
                  return 0
              floor = np.median(x) + 1e-6
              hi = np.min([x[k:k + n] for k in HIGH], axis=0)
              lo = np.mean([x[k:k + n] for k in QUIET], axis=0)
              cand = np.flatnonzero((hi > 3 * floor) & (hi > 2.5 * lo))
              skip = -1
              for i in cand:
                  if i < skip:
                      continue
                  c = x[i + 16:i + N]
                  b = c[0::2] > c[1::2]
                  df = val(b[:5])
                  if df not in (17, 18):
                      continue
                  if remainder(b):
                      self.bad += 1
                      continue
                  self.good += 1
                  skip = i + N
                  self.report(b, (self.nitems_read(0) + i) / self.fs)
              return n

          def report(self, b, t):
              icao = f'{val(b[8:32]):06X}'
              me = b[32:88]
              tc = val(me[:5])
              p = self.planes.setdefault(icao, {})
              what = f'type code {tc}'
              if 1 <= tc <= 4:
                  p['call'] = ''.join(CHARS[val(me[8 + 6 * k:14 + 6 * k])] for k in range(8)).strip(' #')
                  what = f'callsign {p["call"]}'
              elif 9 <= tc <= 18:
                  a = me[8:20]
                  p['alt'] = val(np.r_[a[:7], a[8:]]) * 25 - 1000 if a[7] else None
                  odd = int(me[21])
                  yz, xz = val(me[22:39]) / 2 ** 17, val(me[39:56]) / 2 ** 17
                  dlat = 360 / (59 if odd else 60)
                  lat = dlat * (math.floor(self.ref[0] / dlat)
                                + math.floor(0.5 + (self.ref[0] % dlat) / dlat - yz) + yz)
                  dlon = 360 / max(nl(lat) - odd, 1)
                  lon = dlon * (math.floor(self.ref[1] / dlon)
                                + math.floor(0.5 + (self.ref[1] % dlon) / dlon - xz) + xz)
                  p['pos'] = (lat, lon)
                  what = f'altitude {p["alt"]} ft, position {lat:.4f}, {lon:.4f}'
              elif tc == 19 and val(me[5:8]) in (1, 2):
                  ve = (val(me[14:24]) - 1) * (-1 if me[13] else 1)
                  vn = (val(me[25:35]) - 1) * (-1 if me[24] else 1)
                  p['spd'] = round(math.hypot(ve, vn))
                  p['trk'] = round(math.degrees(math.atan2(ve, vn)) % 360)
                  p['vr'] = (val(me[37:46]) - 1) * 64 * (-1 if me[36] else 1)
                  what = f'{p["spd"]} kt, track {p["trk"]} deg, {p["vr"]:+d} ft/min'
              p['t'] = t
              print(f'{t:8.4f} s  {val(b):028X}  ICAO {icao}  {what}', flush=True)

          def stats(self):
              return f'{self.good} passed parity, {self.bad} failed'

          def table(self):
              rows = []
              for icao, p in sorted(self.planes.items()):
                  pos = p.get('pos')
                  rows.append(f'{icao}  {p.get("call", "?")}:  {p.get("alt", "?")} ft,  '
                              f'{p.get("spd", "?")} kt,  track {p.get("trk", "?")},  '
                              + (f'{pos[0]:.3f}, {pos[1]:.3f}' if pos else 'position ?'))
              return '\n'.join(rows) or '(no aircraft yet)'
    ref_lat: '38.99'
    ref_lon: '-104.86'
    samp_rate: samp_rate
    settings: (noise,)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"20 ms of pulses"'
    size: '40000'
    srate: samp_rate
    type: float
    update_time: '0.2'
    ylabel: '"Magnitude"'
    ymax: '1.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: '"One message: preamble and first bits"'
    size: '120'
    srate: samp_rate
    tr_delay: '5e-6'
    tr_level: '0.3'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.1'
    ylabel: '"Magnitude"'
    ymax: '1.2'
    ymin: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 1090e6
    dev_args: ''''''
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
