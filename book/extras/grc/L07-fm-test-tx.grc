options:
  parameters:
    author: ECE 448
    description: 'L7: writes L07-fm-test.sigmf-data and .sigmf-meta, 4 s of 2.4 MS/s IQ centered on 100.0 MHz. Station A at 100.3 MHz carries a two-tone message and RDS; station B at 99.5 MHz carries a different test tone. Simulated; nothing transmits.'
    generate_options: no_gui
    id: L07_fm_test_tx
    output_language: python
    run_options: run
    title: L7 - FM Test File
  states: {}

blocks:
- name: dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: mpx_rate
  id: variable
  parameters:
    value: 240e3
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: offset_a
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: offset_b
  id: variable
  parameters:
    value: '-500e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: seconds
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: band
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: biphase_map
  id: digital_map_bb
  parameters:
    map: '[1, 2]'
  states: {}
- name: diff_encoder
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: duration
  id: blocks_head
  parameters:
    num_items: int(seconds * samp_rate)
    type: complex
  states: {}
- name: file_sink
  id: blocks_sigmf_sink_minimal
  parameters:
    author: ECE 448
    center_freq: 100e6
    description: 'L7 FM test band, Simulated: station A at 100.3 MHz (two-tone message and RDS), station B at 99.5 MHz.'
    filename: L07-fm-test
    hw_info: Simulated in GNU Radio; no radio
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: fm_mod_a
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * dev / samp_rate
  states: {}
- name: fm_mod_b
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * dev / samp_rate
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: lo_a
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: offset_a
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: lo_b
  id: analog_sig_source_x
  parameters:
    amp: '0.25'
    freq: offset_b
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: message
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: mpx
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '448'
    type: complex
  states: {}
- name: preemphasis
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: mpx_rate
    tau: '75e-6'
  states: {}
- name: preemphasis_b
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: mpx_rate
    tau: '75e-6'
  states: {}
- name: rds_encoder
  id: rds_encoder
  parameters:
    af1: 100.3e6
    ms: 'True'
    pi_country_code: '1'
    pi_coverage_area: '0'
    pi_reference_number: '147'
    ps: '"ECE 448"'
    pty: '2'
    pty_locale: '1'
    radiotext: '"USAFA ECE 448 test signal, simulated"'
    ta: 'False'
    tp: 'False'
  states: {}
- name: rds_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: rds_mixer
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: rds_resample
  id: rational_resampler_xxx
  parameters:
    decim: '19'
    interp: '240'
    type: fff
  states: {}
- name: rrc_shaping
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    gain: '8'
    interp: '8'
    ntaps: 8 * 11
    samp_rate: 19e3
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}
- name: shift_a
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: shift_b
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: subcarrier_57k
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: mpx_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: tone_1k
  id: analog_sig_source_x
  parameters:
    amp: '0.6'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: mpx_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tone_2k5
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: '2500'
    offset: '0'
    phase: '0'
    samp_rate: mpx_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tone_600
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: '600'
    offset: '0'
    phase: '0'
    samp_rate: mpx_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: unpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: upsample_a
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}
- name: upsample_b
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}

connections:
- [audio_level, '0', mpx, '0']
- [band, '0', duration, '0']
- [biphase_map, '0', unpack, '0']
- [diff_encoder, '0', biphase_map, '0']
- [duration, '0', file_sink, '0']
- [fm_mod_a, '0', shift_a, '0']
- [fm_mod_b, '0', shift_b, '0']
- [lo_a, '0', shift_a, '1']
- [lo_b, '0', shift_b, '1']
- [message, '0', preemphasis, '0']
- [mpx, '0', upsample_a, '0']
- [noise, '0', band, '2']
- [preemphasis, '0', audio_level, '0']
- [preemphasis_b, '0', upsample_b, '0']
- [rds_encoder, '0', diff_encoder, '0']
- [rds_level, '0', mpx, '1']
- [rds_mixer, '0', rds_level, '0']
- [rds_resample, '0', rds_mixer, '0']
- [rrc_shaping, '0', rds_resample, '0']
- [shift_a, '0', band, '0']
- [shift_b, '0', band, '1']
- [subcarrier_57k, '0', rds_mixer, '1']
- [symbols, '0', rrc_shaping, '0']
- [tone_1k, '0', message, '0']
- [tone_2k5, '0', message, '1']
- [tone_600, '0', preemphasis_b, '0']
- [unpack, '0', symbols, '0']
- [upsample_a, '0', fm_mod_a, '0']
- [upsample_b, '0', fm_mod_b, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
