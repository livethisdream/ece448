options:
  parameters:
    author: ECE 448
    description: 'L19: receive AIS channels A and B from L19-ais-sim.sigmf-data (96 kS/s, centered on 162 MHz): shift each channel to 0 Hz, squelch the noise between bursts, FM-demodulate it, recover the bit timing, slice the bits, and decode them with the AIS Decoder, an Embedded Python Block. To receive with a PlutoSDR, disable the SigMF Source and the Throttle and enable the PlutoSDR Source, its Low Pass Filter, and its AGC, and start the squelch near -10 dB: fc 915e6 for L19-ais-tx-pluto.grc through the cable, or 162e6 for live AIS on a coast. Receive only.'
    generate_options: qt_gui
    id: L19_ais_rx
    output_language: python
    title: L19 - AIS Receiver
  states: {}

blocks:
- name: chan_a
  id: variable
  parameters:
    value: '-25e3'
  states: {}
- name: chan_b
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 162e6
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Added noise
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 6 * samp_rate
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,2
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / decim / 9600
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Squelch (dB)
    start: '-60'
    step: '1'
    stop: '0'
    value: '-25'
  states: {}
- name: stats
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: stats
    poll_rate: '2'
    value: ''''''
  states: {}
- name: stats_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: Frames
    type: string
    value: stats
  states: {}
- name: table
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: table
    poll_rate: '2'
    value: ''''''
  states: {}
- name: table_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,2
    label: Ships
    type: string
    value: table
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 7e3, 3e3)
  states: {}
- name: add_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: agc_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e9
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: demod_a
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / decim / (2 * math.pi * 2400)
  states: {}
- name: demod_b
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / decim / (2 * math.pi * 2400)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """AIS Decoder: turns the sliced bits of channels A and B into AIS messages.

      For each channel, one bit at a time:
      1. Undo NRZI: a bit that keeps the level is a 1, a change is a 0.
      2. Find the start flag, 01111110, and collect bits up to the end flag.
      3. Remove the stuffed bits: drop the 0 that follows five 1s.
      4. Check the 16-bit CRC. A frame that fails is counted and dropped.
      5. Put each byte's bits back in order, print the message as an NMEA
         !AIVDM sentence, and decode the fields a chart plotter would show.

      Function Probes read stats() and table() for the QT GUI Labels."""

      import numpy as np
      from gnuradio import gr

      SIX = '@ABCDEFGHIJKLMNOPQRSTUVWXYZ[\\]^_ !"#$%&\'()*+,-./0123456789:;<=>?'
      FLAG = 0x7E


      def val(b, signed=False):
          v = 0
          for x in b:
              v = (v << 1) | x
          return v - (1 << len(b)) if signed and b[0] else v


      def crc_ok(b):
          reg = 0xFFFF
          for x in b:
              reg = (reg >> 1) ^ 0x8408 if (reg ^ x) & 1 else reg >> 1
          return reg == 0xF0B8


      def nmea(p, chan):
          fill = -len(p) % 6
          p = p + [0] * fill
          s = ''.join(chr(v + 48 if v < 40 else v + 56)
                      for v in (val(p[i:i + 6]) for i in range(0, len(p), 6)))
          parts = [s[i:i + 60] for i in range(0, len(s), 60)]
          out = []
          for k, part in enumerate(parts):
              f = fill if k == len(parts) - 1 else 0
              body = f'AIVDM,{len(parts)},{k + 1},{"1" if len(parts) > 1 else ""},{chan},{part},{f}'
              cs = 0
              for c in body:
                  cs ^= ord(c)
              out.append(f'!{body}*{cs:02X}')
          return out


      class Channel:
          def __init__(self):
              self.prev = 0
              self.shift = 0
              self.frame = None
              self.trained = False

          def bit(self, level):
              """Feed one sliced bit. At a flag, returns (bits since the last flag,
              whether the training bits came before it); otherwise None."""
              b = 1 if level == self.prev else 0
              self.prev = level
              self.shift = ((self.shift << 1) | b) & 0xFFFF
              if self.frame is not None:
                  self.frame.append(b)
                  if len(self.frame) > 1100:
                      self.frame = None
              if self.shift & 0xFF != FLAG:
                  return None
              done = None
              if self.frame is not None and len(self.frame) > 8:
                  done = (self.frame[:-8], self.trained)
              # A new frame may start here. Training bits, 0101..., before the
              # flag mark a real start rather than noise that happens to match.
              self.trained = (self.shift >> 8) in (0x55, 0xAA)
              self.frame = []
              return done


      class blk(gr.sync_block):
          def __init__(self, settings=None):
              gr.sync_block.__init__(self, name='AIS Decoder', in_sig=[np.uint8, np.uint8], out_sig=None)
              self.ch = {'A': Channel(), 'B': Channel()}
              self.settings = settings

          @property
          def settings(self):
              return self._settings

          @settings.setter
          def settings(self, value):
              # GRC sets this when a slider it names moves: the counts and the
              # table start over.
              self._settings = value
              self.ships = {}
              self.good = 0
              self.bad = 0

          def work(self, input_items, output_items):
              for name, x in zip('AB', input_items):
                  c = self.ch[name]
                  for level in x:
                      got = c.bit(int(level))
                      if got is not None and self.frame(*got, name):
                          c.frame = None    # one frame per burst
              return len(input_items[0])

          def frame(self, raw, trained, chan):
              """Unstuff and check one frame. True if it passed the CRC."""
              b, run = [], 0
              for x in raw:
                  if run == 5:          # the 0 after five 1s was stuffed
                      run = 0
                      continue
                  b.append(x)
                  run = run + 1 if x else 0
              if len(b) < 72 or (len(b) - 16) % 8 or not crc_ok(b):
                  self.bad += trained and len(b) >= 72
                  return False
              self.good += 1
              p = []
              for i in range(0, len(b) - 16, 8):
                  p += b[i:i + 8][::-1]
              self.report(p, chan)
              return True

          def report(self, p, chan):
              mtype, mmsi = val(p[0:6]), val(p[8:38])
              s = self.ships.setdefault(mmsi, {})
              what = f'message {mtype}'
              if mtype in (1, 2, 3) and len(p) >= 168:
                  s['sog'] = val(p[50:60]) / 10
                  s['lon'] = val(p[61:89], True) / 600000
                  s['lat'] = val(p[89:116], True) / 600000
                  s['cog'] = val(p[116:128]) / 10
                  what = f'position {s["lat"]:.4f}, {s["lon"]:.4f}, {s["sog"]} kt, course {s["cog"]}'
              elif mtype == 18 and len(p) >= 168:
                  s['sog'] = val(p[46:56]) / 10
                  s['lon'] = val(p[57:85], True) / 600000
                  s['lat'] = val(p[85:112], True) / 600000
                  s['cog'] = val(p[112:124]) / 10
                  what = f'class B position {s["lat"]:.4f}, {s["lon"]:.4f}, {s["sog"]} kt'
              elif mtype == 5 and len(p) >= 420:
                  txt = lambda a, n: ''.join(SIX[val(p[a + 6 * i:a + 6 * i + 6])] for i in range(n)).strip('@ ')
                  s['name'], s['dest'] = txt(112, 20), txt(302, 20)
                  s['type'] = val(p[232:240])
                  s['len'] = val(p[240:249]) + val(p[249:258])
                  what = f'name {s["name"]}, callsign {txt(70, 7)}, type {s["type"]}, {s["len"]} m, to {s["dest"]}'
              elif mtype == 24 and len(p) >= 160 and val(p[38:40]) == 0:
                  s['name'] = ''.join(SIX[val(p[40 + 6 * i:46 + 6 * i])] for i in range(20)).strip('@ ')
                  what = f'name {s["name"]}'
              for line in nmea(p, chan):
                  print(line, flush=True)
              print(f'    channel {chan}  MMSI {mmsi}  {what}', flush=True)

          def stats(self):
              return f'{self.good} passed CRC, {self.bad} failed'

          def table(self):
              rows = []
              for mmsi, s in sorted(self.ships.items()):
                  pos = f'{s["lat"]:.4f}, {s["lon"]:.4f}' if 'lat' in s else 'position ?'
                  rows.append(f'{mmsi}  {s.get("name", "?")}:  {pos},  {s.get("sog", "?")} kt,  '
                              f'course {s.get("cog", "?")}')
              return '\n'.join(rows) or '(no ships yet)'
    settings: (noise,)
  states: {}
- name: lpf_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '6'
    gain: '1'
    samp_rate: radio_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: noise_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: pluto_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(radio_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: slice_a
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: slice_b
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: sq_a
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.05'
    gate: 'False'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: sq_b
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.05'
    gate: 'False'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: src_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: '''L19-ais-sim.sigmf-data'''
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: sync_a
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.06'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: sync_b
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.06'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: time_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: '"Channel A"'
    label2: '"Channel B"'
    name: '"FM demodulator output: the start of one burst"'
    nconnections: '2'
    size: '480'
    srate: samp_rate / decim
    tr_delay: '0.001'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.1'
    ylabel: '"Frequency (x 2.4 kHz)"'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: wf_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '512'
    gui_hint: 2,0,1,1
    int_max: '-20'
    int_min: '-75'
    legend: 'False'
    name: '"Channels A and B"'
    type: complex
    update_time: '0.05'
  states: {}
- name: xlate_a
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan_a
    decim: decim
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: xlate_b
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan_b
    decim: decim
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}

connections:
- [add_0, '0', wf_0, '0']
- [add_0, '0', xlate_a, '0']
- [add_0, '0', xlate_b, '0']
- [agc_0, '0', add_0, '0']
- [demod_a, '0', sync_a, '0']
- [demod_a, '0', time_0, '0']
- [demod_b, '0', sync_b, '0']
- [demod_b, '0', time_0, '1']
- [lpf_0, '0', agc_0, '0']
- [noise_0, '0', add_0, '1']
- [pluto_0, '0', lpf_0, '0']
- [slice_a, '0', epy_block_0, '0']
- [slice_b, '0', epy_block_0, '1']
- [sq_a, '0', demod_a, '0']
- [sq_b, '0', demod_b, '0']
- [src_0, '0', throttle_0, '0']
- [sync_a, '0', slice_a, '0']
- [sync_b, '0', slice_b, '0']
- [throttle_0, '0', add_0, '0']
- [xlate_a, '0', sq_a, '0']
- [xlate_b, '0', sq_b, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
