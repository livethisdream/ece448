options:
  parameters:
    author: ECE 448
    description: 'L11: the Energy Detector on an RTL-SDR at 433.92 MHz, keying on the bursts of an on-off keyed remote. Receive only.'
    generate_options: qt_gui
    id: L11_ook_rtlsdr
    output_language: python
    title: L11 - OOK Remote on an RTL-SDR
  states: {}

blocks:
- name: hyst
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Hysteresis (dB)
    start: '0'
    step: '0.5'
    stop: '10'
    value: '3'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '50000'
    gain: '1'
    samp_rate: samp_rate
    width: '14000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Threshold (dB)
    start: '-70'
    step: '0.5'
    stop: '0'
    value: '-35'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-60'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: ece448_energy_detector_0
  id: ece448_energy_detector
  parameters:
    decim: '4'
    hysteresis_db: hyst
    threshold_db: threshold
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '8'
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / 8
    fc: 433.92e6
    fftsize: '1024'
    gui_hint: 1,0,1,3
    name: '"433.92 MHz"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color3: dark green
    entags: 'False'
    gui_hint: 2,0,1,3
    label1: Power
    label2: Key (-60 off, -40 on)
    label3: Threshold
    name: '"Power and key"'
    nconnections: '3'
    size: '3200'
    srate: samp_rate / 32
    style3: '2'
    tr_chan: '1'
    tr_delay: '0.005'
    tr_level: '-50'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    width1: '2'
    ylabel: Power
    ymax: '0'
    ymin: '-70'
    yunit: dB
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 433.92e6 - offset
    dev_args: ''''''
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [ece448_energy_detector_0, '0', qtgui_time_sink_x_0, '0']
- [ece448_energy_detector_0, '1', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ece448_energy_detector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
