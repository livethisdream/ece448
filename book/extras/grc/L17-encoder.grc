options:
  parameters:
    author: ECE 448
    category: '[ECE 448]'
    description: 'L17: OOK pulse encoder hier block. Each input bit (0 or 1) becomes a pattern of on/off chips, each chip held for chip_len samples. Press Generate once to install it as L17 OOK Encoder. It transmits nothing by itself.'
    generate_options: qt_gui
    id: L17_ook_encoder
    output_language: python
    title: L17 OOK Encoder
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: chip_len
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: chips_per_bit
  states: {}
- name: chip_len
  id: parameter
  parameters:
    label: Samples per chip
    type: intx
    value: '80'
  states: {}
- name: chips_per_bit
  id: parameter
  parameters:
    label: Chips per bit
    type: intx
    value: '3'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: pattern
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: envelope
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: bits
    type: byte
  states: {}
- name: pattern
  id: parameter
  parameters:
    label: Chip pattern for 0 and 1
    value: '[4, 6]'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', pad_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pad_source_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
