options:
  parameters:
    author: ECE 448
    description: 'L20: receive only; nothing transmits. A PlutoSDR Source with spectrum and waterfall displays, a Center frequency control, and a Sample rate choice. At 2 MS/s the Pluto streams continuously over USB 2.0: use it for HD Radio near 100 MHz. At 20 MS/s it cannot, so each 131072-sample buffer (6.5 ms) is a contiguous burst with gaps between buffers; the spectrum and waterfall still show the shape of a Wi-Fi or LTE channel. Needs a PlutoSDR in extended-frequency mode (70 MHz to 6 GHz). The RF bandwidth stays at 20 MHz for both rates; at 2 MS/s the Pluto''s digital filter narrows it. Opens at 2 MS/s and 100.1 MHz.'
    generate_options: qt_gui
    id: L20_band_pluto
    output_language: python
    title: L20 - OFDM on the Air (PlutoSDR)
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center frequency (Hz)
    start: 70e6
    step: 100e3
    stop: 6e9
    value: 100.1e6
    widget: counter
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Sample rate
    label0: 2 MS/s (live)
    label1: 20 MS/s (bursts)
    num_opts: '2'
    option0: '2000000'
    option1: '20000000'
    orient: Qt.QHBoxLayout
    type: int
    value: '2000000'
    widget: radio_buttons
  states: {}
- name: freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: 1,0,1,3
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: 2,0,1,3
    int_max: '-30'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [pluto_rx, '0', freq, '0']
- [pluto_rx, '0', wf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
