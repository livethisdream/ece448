options:
  parameters:
    author: ECE 448
    description: 'L17: receive only. A PlutoSDR Source with spectrum, waterfall, and envelope displays, recording to capture.sigmf-data and .sigmf-meta. Set the variable fc before you run it: the SigMF Sink writes core:frequency when the flowgraph starts, so fc is not a runtime control. The AGC feeds only the envelope display; the recording keeps the raw samples. Needs a PlutoSDR; L17-capture-rtl.grc is an optional RTL-SDR version.'
    generate_options: qt_gui
    id: L17_capture
    output_language: python
    title: L17 - Capture to SigMF
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 350e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: agc
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '0.0001'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000000.0'
    reference: '1.0'
    type: complex
  states: {}
- name: env
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Envelope (after the AGC, display only)"'
    size: '50000'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: rec
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: fc
    filename: capture
    hw_info: PlutoSDR
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: 1,1,1,1
    int_max: '-30'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [agc, '0', mag, '0']
- [mag, '0', env, '0']
- [pluto_rx, '0', agc, '0']
- [pluto_rx, '0', freq, '0']
- [pluto_rx, '0', rec, '0']
- [pluto_rx, '0', wf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
