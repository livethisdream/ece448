options:
  parameters:
    author: ECE 448
    description: 'L13: a narrowband FM receiver on a PlutoSDR feeding the DTMF Decoder. Type a channel that carries DTMF into Channel (MHz), such as a local amateur repeater. Receive only: there is no transmit block. Needs a PlutoSDR.'
    generate_options: qt_gui
    id: L13_nfm_pluto
    output_language: python
    title: L13 - DTMF over Narrowband FM on a PlutoSDR
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '205'
  states: {}
- name: chan_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Channel (MHz)
    type: real
    value: '146.52'
  states: {}
- name: chan_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 8e3
    gain: '1'
    samp_rate: radio_rate
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: digits_lbl
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: '':  '' + x'
    gui_hint: 0,0,1,1
    label: Digits
    type: string
    value: rx_digits
  states: {}
- name: offset
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate * 6
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: quad_rate * 32
  states: {}
- name: rx_digits
  id: variable_function_probe
  parameters:
    block_id: dtmf_decoder
    function_name: digits
    poll_rate: '4'
    value: '''(listening)'''
  states: {}
- name: rx_stats
  id: variable_function_probe
  parameters:
    block_id: dtmf_decoder
    function_name: stats
    poll_rate: '4'
    value: ''''''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: stats_lbl
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: '':  '' + x'
    gui_hint: 0,1,1,1
    label: Numbers
    type: string
    value: rx_stats
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.5'
  states: {}
- name: band
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    fc: chan_mhz * 1e6 - offset
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,0,1,1
    legend: 'False'
    name: '"Band (the channel is 200 kHz right of center)"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: band_wf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: radio_rate
    fc: chan_mhz * 1e6 - offset
    fftsize: '2048'
    gui_hint: 4,1,1,1
    int_max: '-40'
    int_min: '-120'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: cols
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: 1209 Hz
    label2: 1336 Hz
    label3: 1477 Hz
    label4: 1633 Hz
    name: '"Column bins (Goertzel, |X|/N)"'
    nconnections: '4'
    size: '117'
    srate: samp_rate / N
    type: float
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ylabel: Amplitude / 2
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: dtmf_decoder
  id: epy_block
  parameters:
    N: N
    _source_code: |
      """DTMF Decoder: a Goertzel bin at each of the eight DTMF frequencies, read
      once per block of N samples, with a new block every N/2 samples.

      A block holds a digit when the strongest row bin and the strongest column bin
      carry at least `share` of the block's energy, each is at least 6 dB above the
      other three bins in its group, and the column tone is no more than 6 dB above
      or 10 dB below the row tone. A digit is reported when three blocks in a row hold it, and
      again only after a block that does not.
      A pause of 200 ms or more ends a number. The counts start over when a setting
      changes, and a number that is not decoded never counts.
      Function Probes read digits() and stats() for the QT GUI Labels."""

      import time

      import numpy as np
      from gnuradio import gr

      ROWS = (697, 770, 852, 941)
      COLS = (1209, 1336, 1477, 1633)
      KEYS = ('123A', '456B', '789C', '*0#D')


      class blk(gr.sync_block):
          def __init__(self, samp_rate=8000, N=205, share=0.35, round_k=False,
                       expected='', settings=None):
              gr.sync_block.__init__(self, name='DTMF Decoder', in_sig=[np.float32], out_sig=None)
              self.fs = samp_rate
              self.N = int(N)
              self.share = share
              self.round_k = round_k
              self.expected = expected
              self.settings = settings

          @property
          def settings(self):
              return self._settings

          @settings.setter
          def settings(self, value):
              # GRC sets this whenever a setting it names changes; start the counts over,
              # and drop the first number after a change, which may mix old and new samples.
              self.discard = hasattr(self, '_settings')
              self._settings = value
              k = np.array(ROWS + COLS) * self.N / self.fs       # bin number of each tone
              if self.round_k:
                  k = np.round(k)
              self.coef = 2 * np.cos(2 * np.pi * k / self.N)
              self.hop = self.N // 2
              self.buf = np.zeros(0, dtype=np.float32)
              self.prev = self.held = None
              self.run = 0
              self.quiet = 0
              self.number = ''
              self.shown = '(listening)'
              self.good = self.total = 0
              self.t0 = time.monotonic()

          def goertzel(self, x):
              q1 = np.zeros(8)
              q2 = np.zeros(8)
              for v in x:
                  q1, q2 = self.coef * q1 - q2 + v, q1
              return q1 * q1 + q2 * q2 - self.coef * q1 * q2      # |X(k)|^2 for each tone

          def decide(self, x):
              energy = np.dot(x, x)
              if energy < 1e-8:
                  return None
              p = self.goertzel(x) * 2 / (self.N * energy)          # a lone tone gives 1
              lo, hi = p[:4], p[4:]
              r, c = int(np.argmax(lo)), int(np.argmax(hi))
              if lo[r] + hi[c] < self.share:
                  return None                                       # not enough energy in two tones
              if np.sort(lo)[-2] * 4 > lo[r] or np.sort(hi)[-2] * 4 > hi[c]:
                  return None                                       # no clear winner (6 dB)
              if hi[c] > lo[r] * 10 ** 0.6 or lo[r] > hi[c] * 10 ** 1.0:
                  return None                                       # twist: +6 dB / -10 dB
              return KEYS[r][c]

          def work(self, input_items, output_items):
              self.buf = np.concatenate((self.buf, input_items[0]))
              while len(self.buf) >= self.N:
                  d = self.decide(self.buf[:self.N].astype(np.float64))
                  self.buf = self.buf[self.hop:]
                  self.run = self.run + 1 if d is not None and d == self.prev else int(d is not None)
                  if d != self.held:
                      self.held = None
                  if d is not None and self.run >= 3 and self.held is None:
                      self.number += d
                      self.held = d
                  self.quiet = 0 if d is not None else self.quiet + 1
                  if self.number and self.quiet * self.hop >= 0.2 * self.fs:
                      self.finish()
                  self.prev = d
              return len(input_items[0])

          def finish(self):
              if self.discard:
                  self.discard = False
              else:
                  self.shown = self.number
                  self.total += 1
                  self.good += self.number == str(self.expected).upper()
              self.number = ''

          def digits(self):
              return self.number or self.shown

          def stats(self):
              t = time.monotonic() - self.t0
              if not self.expected:
                  return f'{self.total} decoded in {t:.0f} s'
              return f'{self.good} correct of {self.total} decoded in {t:.0f} s'
    expected: ''''''
    round_k: 'False'
    samp_rate: samp_rate
    settings: None
    share: '0.35'
  states: {}
- name: g1209
  id: goertzel_fc
  parameters:
    freq: '1209'
    len: N
    rate: samp_rate
  states: {}
- name: g1336
  id: goertzel_fc
  parameters:
    freq: '1336'
    len: N
    rate: samp_rate
  states: {}
- name: g1477
  id: goertzel_fc
  parameters:
    freq: '1477'
    len: N
    rate: samp_rate
  states: {}
- name: g1633
  id: goertzel_fc
  parameters:
    freq: '1633'
    len: N
    rate: samp_rate
  states: {}
- name: g697
  id: goertzel_fc
  parameters:
    freq: '697'
    len: N
    rate: samp_rate
  states: {}
- name: g770
  id: goertzel_fc
  parameters:
    freq: '770'
    len: N
    rate: samp_rate
  states: {}
- name: g852
  id: goertzel_fc
  parameters:
    freq: '852'
    len: N
    rate: samp_rate
  states: {}
- name: g941
  id: goertzel_fc
  parameters:
    freq: '941'
    len: N
    rate: samp_rate
  states: {}
- name: m1209
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m1336
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m1477
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m1633
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m697
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m770
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m852
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: m941
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: nbfm
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: pluto_source
  id: iio_pluto_source
  parameters:
    bandwidth: int(radio_rate)
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(chan_mhz * 1e6 - offset)
    gain1: '''slow_attack'''
    len_tag_key: '""'
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(radio_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: rows
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: 697 Hz
    label2: 770 Hz
    label3: 852 Hz
    label4: 941 Hz
    name: '"Row bins (Goertzel, |X|/N)"'
    nconnections: '4'
    size: '117'
    srate: samp_rate / N
    type: float
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ylabel: Amplitude / 2
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: speaker
  id: audio_sink
  parameters:
    device_name: ''''''
    samp_rate: '8000'
  states: {}
- name: tune
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '32'
    samp_rate: radio_rate
    taps: chan_taps
    type: ccc
  states: {}
- name: vol
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: wf
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    freqhalf: 'False'
    gui_hint: 3,0,1,2
    label1: Audio
    name: '"Spectrum"'
    type: float
    ymax: '0'
    ymin: '-80'
  states: {}

connections:
- [g1209, '0', m1209, '0']
- [g1336, '0', m1336, '0']
- [g1477, '0', m1477, '0']
- [g1633, '0', m1633, '0']
- [g697, '0', m697, '0']
- [g770, '0', m770, '0']
- [g852, '0', m852, '0']
- [g941, '0', m941, '0']
- [m1209, '0', cols, '0']
- [m1336, '0', cols, '1']
- [m1477, '0', cols, '2']
- [m1633, '0', cols, '3']
- [m697, '0', rows, '0']
- [m770, '0', rows, '1']
- [m852, '0', rows, '2']
- [m941, '0', rows, '3']
- [nbfm, '0', dtmf_decoder, '0']
- [nbfm, '0', g1209, '0']
- [nbfm, '0', g1336, '0']
- [nbfm, '0', g1477, '0']
- [nbfm, '0', g1633, '0']
- [nbfm, '0', g697, '0']
- [nbfm, '0', g770, '0']
- [nbfm, '0', g852, '0']
- [nbfm, '0', g941, '0']
- [nbfm, '0', vol, '0']
- [nbfm, '0', wf, '0']
- [pluto_source, '0', band, '0']
- [pluto_source, '0', band_wf, '0']
- [pluto_source, '0', tune, '0']
- [tune, '0', nbfm, '0']
- [vol, '0', speaker, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
