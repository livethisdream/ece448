options:
  parameters:
    author: ECE 448
    description: 'L12 Lab: the CW link through one PlutoSDR, transmitting at 915 MHz into a cable from TX to RX through a 30 dB attenuator, or, if your instructor says so, over the air at 915 MHz at low power. Never set TX attenuation below 30 dB.'
    generate_options: qt_gui
    id: L12_cw_pluto
    output_language: python
    title: L12 - CW on a PlutoSDR
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: bfo
  id: variable
  parameters:
    value: '700'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: CW filter width (Hz)
    start: '50'
    step: '10'
    stop: '1000'
    value: '200'
  states: {}
- name: env_rate
  id: variable
  parameters:
    value: audio_rate/8
  states: {}
- name: f_tx
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,3
    label: Message
    type: string
    value: USAFA ECE 448
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: samp_rate*32
  states: {}
- name: rise
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Pluto RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: rx_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: '':  '' + x'
    gui_hint: 3,0,1,2
    label: Received
    type: string
    value: rx_text
  states: {}
- name: rx_text
  id: variable_function_probe
  parameters:
    block_id: epy_block_1
    function_name: text
    poll_rate: '4'
    value: '''(listening)'''
  states: {}
- name: rx_wpm
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Decoder speed (WPM)
    start: '5'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: thr
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Threshold
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: tune
  id: variable
  parameters:
    value: f_tx
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Pluto TX attenuation (dB)
    start: '30'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: wpm
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Sender speed (WPM)
    start: '5'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '0.0001'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000000.0'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: f_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: thr
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: env_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '""'
    samp_rate: '8000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: 1.2*thr
    init: '0'
    low: 0.8*thr
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Morse Keyer: repeats msg as Morse code, one float sample per sample
      period: 1 while the key is down and 0 while it is up. Each edge rises or
      falls along a raised cosine over rise_ms; rise_ms = 0 is hard keying.
      Timing follows the PARIS standard: a dit is one unit of 1.2/wpm seconds,
      a dah three, the gap inside a character one, between characters three,
      and between words seven."""

      import numpy as np
      from gnuradio import gr

      MORSE = {
          'A': '.-', 'B': '-...', 'C': '-.-.', 'D': '-..', 'E': '.', 'F': '..-.', 'G': '--.', 'H': '....',
          'I': '..', 'J': '.---', 'K': '-.-', 'L': '.-..', 'M': '--', 'N': '-.', 'O': '---', 'P': '.--.',
          'Q': '--.-', 'R': '.-.', 'S': '...', 'T': '-', 'U': '..-', 'V': '...-', 'W': '.--', 'X': '-..-',
          'Y': '-.--', 'Z': '--..', '0': '-----', '1': '.----', '2': '..---', '3': '...--', '4': '....-',
          '5': '.....', '6': '-....', '7': '--...', '8': '---..', '9': '----.', '.': '.-.-.-', ',': '--..--',
          '?': '..--..', '/': '-..-.', '=': '-...-', '-': '-....-',
      }


      class blk(gr.sync_block):
          def __init__(self, msg='PARIS', wpm=20.0, rise_ms=5.0, samp_rate=8000.0):
              gr.sync_block.__init__(self, name='Morse Keyer', in_sig=None, out_sig=[np.float32])
              self._msg, self._wpm, self._rise_ms, self.samp_rate = msg, wpm, rise_ms, samp_rate
              self.pos = 0
              self.build()

          # GRC assigns these when a slider or entry changes; each one rebuilds the
          # envelope and starts the message again.
          @property
          def msg(self): return self._msg
          @msg.setter
          def msg(self, v): self._msg = v; self.build()
          @property
          def wpm(self): return self._wpm
          @wpm.setter
          def wpm(self, v): self._wpm = v; self.build()
          @property
          def rise_ms(self): return self._rise_ms
          @rise_ms.setter
          def rise_ms(self, v): self._rise_ms = v; self.build()

          def build(self):
              units = []                                   # one 0 or 1 per unit
              for word in str(self._msg).upper().split():
                  for c in word:
                      for s in MORSE.get(c, ''):
                          units += [1] * (1 if s == '.' else 3) + [0]
                      units += [0, 0]                      # character gap: 3 units
                  units += [0] * 4                         # word gap: 7 units
              units = np.array(units or [0], dtype=np.float32)
              spu = 1.2 / self._wpm * self.samp_rate       # samples per unit
              n = int(round(len(units) * spu))
              key = units[np.minimum((np.arange(n) / spu).astype(int), len(units) - 1)]
              m = int(round(self._rise_ms * 1e-3 * self.samp_rate))
              if m >= 2:
                  # A half-sine pulse sums to a raised-cosine step, so filtering the
                  # hard-keyed waveform with it shapes every edge the same way.
                  h = np.sin(np.pi * (np.arange(m) + 0.5) / m)
                  h /= h.sum()
                  key = np.real(np.fft.ifft(np.fft.fft(key) * np.fft.fft(h, n)))
                  key = np.roll(key, -(m // 2)).astype(np.float32)
              self.env = key
              self.pos = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n, k = len(out), len(self.env)
              idx = (self.pos + np.arange(n)) % k
              out[:] = self.env[idx]
              self.pos = (self.pos + n) % k
              return n
    msg: msg
    rise_ms: rise
    samp_rate: samp_rate
    wpm: wpm
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """CW Decoder: turns the keyed 0/1 stream from the threshold into text.
      It measures each mark and space in units of 1.2/wpm seconds. A mark shorter
      than 2 units is a dit and a longer one a dah; a space of 2 units ends a
      character and a space of 5 ends a word. A change that lasts less than 0.3
      unit is noise, and the decoder ignores it. A Function Probe reads text()."""

      import numpy as np
      from gnuradio import gr

      DECODE = {
          '.-': 'A', '-...': 'B', '-.-.': 'C', '-..': 'D', '.': 'E', '..-.': 'F', '--.': 'G', '....': 'H',
          '..': 'I', '.---': 'J', '-.-': 'K', '.-..': 'L', '--': 'M', '-.': 'N', '---': 'O', '.--.': 'P',
          '--.-': 'Q', '.-.': 'R', '...': 'S', '-': 'T', '..-': 'U', '...-': 'V', '.--': 'W', '-..-': 'X',
          '-.--': 'Y', '--..': 'Z', '-----': '0', '.----': '1', '..---': '2', '...--': '3', '....-': '4',
          '.....': '5', '-....': '6', '--...': '7', '---..': '8', '----.': '9', '.-.-.-': '.', '--..--': ',',
          '..--..': '?', '-..-.': '/', '-...-': '=', '-....-': '-',
      }


      class blk(gr.sync_block):
          def __init__(self, wpm=20.0, samp_rate=1000.0):
              gr.sync_block.__init__(self, name='CW Decoder', in_sig=[np.float32], out_sig=None)
              self.samp_rate = samp_rate
              self.wpm = wpm
              self.level, self.run, self.pending = 0, 0, 0
              self.sym, self.out, self.word_done = '', '', True

          @property
          def wpm(self): return self._wpm
          @wpm.setter
          def wpm(self, v):
              self._wpm = v
              self.spu = 1.2 / v * self.samp_rate         # samples per unit
              self.glitch = max(1, int(0.3 * self.spu))

          def work(self, input_items, output_items):
              for b in input_items[0] > 0.5:
                  if b == self.level:
                      self.run += 1
                      self.pending = 0
                  else:
                      self.pending += 1
                      if self.pending < self.glitch:       # too short to be a real change
                          self.run += 1
                          continue
                      if self.level:                       # a mark just ended
                          units = (self.run - self.pending + 1) / self.spu
                          self.sym += '.' if units < 2 else '-'
                      self.level, self.run, self.pending = int(b), self.pending, 0
                      self.word_done = self.word_done and not b
                  if not self.level and not self.word_done:
                      units = self.run / self.spu
                      if units >= 2 and self.sym:          # end of a character
                          self.out += DECODE.get(self.sym, '#')
                          self.sym = ''
                      if units >= 5:                       # end of a word
                          self.out += ' '
                          self.word_done = True
              self.out = self.out[-4000:]
              return len(input_items[0])

          def text(self):
              return self.out[-60:] or '(listening)'

          def all_text(self):
              return self.out
    samp_rate: env_rate
    wpm: rx_wpm
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1, audio_rate, bfo - bw/2, bfo + bw/2, max(bw/4, 25))
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: firdes.low_pass(1, audio_rate, 100, 100)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune
    decim: '4'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 600, 400)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc)
    len_tag_key: '""'
    samplerate: int(radio_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(fc)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(radio_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,2
    label1: '"envelope"'
    label2: '"threshold"'
    name: '"Envelope (blue) and threshold (red)"'
    nconnections: '2'
    size: '3000'
    srate: env_rate
    type: float
    update_time: '0.1'
    ylabel: '"Level"'
    ymax: '1.2'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    gui_hint: 2,0,1,1
    int_max: '-40'
    int_min: '-120'
    name: '"Received spectrum"'
    type: complex
    update_time: '0.03'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '32'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_2, '0', qtgui_time_sink_x_0, '1']
- [blocks_abs_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_xx_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1, '0']
- [epy_block_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_xx_1, '0']
- [fir_filter_xxx_1, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc3_xx_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
