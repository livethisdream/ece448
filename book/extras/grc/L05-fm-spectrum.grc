options:
  parameters:
    author: ECE 448
    description: 'L5: the broadcast FM band from a PlutoSDR in extended-frequency mode (70 MHz to 6 GHz), in the frequency domain and as a waterfall. Enable the SigMF Sink to record IQ to fm_capture.sigmf-data and .sigmf-meta; it writes the center frequency when the run starts.'
    generate_options: qt_gui
    id: L05_fm_spectrum
    output_language: python
    title: L5 - Broadcast FM on a PlutoSDR
  states: {}

blocks:
- name: dc_track
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,1,1,1
    label: DC tracking
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center frequency (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100.1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: dc_track
    buffer_size: '32768'
    filter: '""'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: gain
    quadrature: 'True'
    rfdc: dc_track
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 2,0,1,2
    name: '"Broadcast FM"'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: sigmf_sink
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: freq
    description: L5 Lab FM band capture
    filename: fm_capture
    hw_info: PlutoSDR
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {state: disabled}

connections:
- [pluto, '0', qtgui_sink_x_0, '0']
- [pluto, '0', sigmf_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
