options:
  parameters:
    author: ECE 448
    description: 'L5: the broadcast FM band from an RTL-SDR, in the frequency domain and as a waterfall. Enable the File Sink to record IQ.'
    generate_options: qt_gui
    id: L05_fm_spectrum
    output_language: python
    title: L5 - Broadcast FM on an RTL-SDR
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center frequency (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100.1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fm_capture.cfile
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 2,0,1,2
    name: '"Broadcast FM"'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
